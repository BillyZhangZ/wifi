# Keil uVision project bsp_k22fsh.uvprojx, settings and files
target bsp_k22fsh Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bsp (library)
  AfterMake: ../../../../mqx/build/bat/bsp_k22fsh.bat ../../../.. ../../../../lib/k22fsh.uv4/debug/bsp uv4 & ".copy.bat" "Debug/bsp.lib" "../../../../lib/k22fsh.uv4/debug/bsp/bsp.lib"
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 
 --library_type=standardlib 
--c99
 --diag_suppress=1296,186
  c include: ../../../source/io/adc/kadc;../../../source/io/adc;../../../source/io/cm;../../../../config/k22fsh;../../../source/io/dma;../../../source/io/flashx/freescale;../../../source/io/flashx;../../../source/io/gpio/kgpio;../../../source/io/gpio;../../../source/io/hwtimer;../../../source/io/i2c;../../../source/io/i2c/polled;../../../source/io/i2c/int;../../../source/bsp/k22fsh;../../../../config/common;../../../source/include;../../../source/io/enet;../../../source/io/debug;../../../source/io/io_mem;../../../source/io/io_null;../../../source/io/pipe;../../../source/io/lpm;../../../source/io/lwadc;../../../source/io/lwgpio;../../../source/io/pcb;../../../source/io/pcb/mqxa;../../../source/io/pccard;../../../source/io/pcflash;../../../source/io/rnga;../../../source/io/rtc;../../../source/io/sai;../../../source/io/sai/int;../../../source/io/sdcard/sdcard_spi;../../../source/io/sdcard;../../../source/io/serial;../../../source/io/spi;../../../source/io/tfs;../../../source/io/timer;../../../source/io/usb;../../../source/psp/cortex_m/compiler/rv_uv4;../../../source/psp/cortex_m/cpu;../../../source/psp/cortex_m;../../../source/psp/cortex_m/core/M4;../../../source/tad;../../../../mux/source
  asm define: _DEBUG=1
  asm misc: --cpreproc 
 --diag_suppress=1609,1581
  asm include: ../../../source/io/adc/kadc;../../../source/io/adc;../../../source/io/cm;../../../../config/k22fsh;../../../source/io/dma;../../../source/io/flashx/freescale;../../../source/io/flashx;../../../source/io/gpio/kgpio;../../../source/io/gpio;../../../source/io/hwtimer;../../../source/io/i2c;../../../source/io/i2c/polled;../../../source/io/i2c/int;../../../source/bsp/k22fsh;../../../../config/common;../../../source/include;../../../source/io/enet;../../../source/io/debug;../../../source/io/io_mem;../../../source/io/io_null;../../../source/io/pipe;../../../source/io/lpm;../../../source/io/lwadc;../../../source/io/lwgpio;../../../source/io/pcb;../../../source/io/pcb/mqxa;../../../source/io/pccard;../../../source/io/pcflash;../../../source/io/rnga;../../../source/io/rtc;../../../source/io/sai;../../../source/io/sai/int;../../../source/io/sdcard/sdcard_spi;../../../source/io/sdcard;../../../source/io/serial;../../../source/io/spi;../../../source/io/tfs;../../../source/io/timer;../../../source/io/usb;../../../source/psp/cortex_m/compiler/rv_uv4;../../../source/psp/cortex_m/cpu;../../../source/psp/cortex_m;../../../source/psp/cortex_m/core/M4;../../../source/tad
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\k22fsh.uv4\mqx\intflash.scf
  group Peripheral IO Drivers/adc
    ../../../source/io/adc/kadc/: adc_mk22.c adc_mk22f.h
    ../../../source/io/adc/: adc.h adc.c adc_conf.h adc_prv.h
  group Peripheral IO Drivers/adc/kadc
    ../../../source/io/adc/kadc/: adc_kadc.c adc_kadc.h adc_kadc_prv.h adt_kpdb.c
  group Generic IO Drivers/cm
    ../../../source/io/cm/: cm_kinetis.h cm.h cm.c
  group User Config
    ../../../../config/k22fsh/: user_config.h
  group Peripheral IO Drivers/dma
    ../../../source/io/dma/: edma_kinetis.c dma.c dma.h edma.c edma.h edma_prv.h
  group Peripheral IO Drivers/flashx
    ../../../source/io/flashx/freescale/: flash_mk22.c flash_mk22.h
    ../../../source/io/flashx/: flashx.c flashx.h flashxprv.h
  group Peripheral IO Drivers/flashx/freescale
    ../../../source/io/flashx/freescale/: flash_ftfa.c flash_ftfa.h flash_ftfa_prv.h
  group Peripheral IO Drivers/gpio/knxx
    ../../../source/io/gpio/kgpio/: io_gpio_kgpio.c io_gpio_kgpio.h io_gpio_kgpio_prv.h
  group Peripheral IO Drivers/gpio
    ../../../source/io/gpio/: io_gpio.h io_gpio.c io_gpio_prv.h
  group Peripheral IO Drivers/hwtimer
    ../../../source/io/hwtimer/: hwtimer_systick.c hwtimer_systick.h hwtimer_lpt.c hwtimer_lpt.h hwtimer_kinetis.c hwtimer_pit.c hwtimer_pit.h hwtimer.c hwtimer.h
  group Peripheral IO Drivers/i2c
    ../../../source/io/i2c/: i2c_mk22.c i2c_ki2c.h i2c_ki2c_prv.h i2c.h
    ../../../source/io/i2c/polled/: i2c_pol_ki2c.c
    ../../../source/io/i2c/int/: i2c_int_ki2c.c
  group Peripheral IO Drivers/i2c/polled
    ../../../source/io/i2c/polled/: i2c_pol_prv.h i2c_pol.c
  group Peripheral IO Drivers/i2c/int
    ../../../source/io/i2c/int/: i2c_int_prv.h i2c_int.c
  group BSP Files
    ../../../source/bsp/k22fsh/: bsp.h bsp_cm.c bsp_cm.h bsp_prv.h bsp_rev.h init_adc.c init_bsp.c init_dma.c init_flashx.c init_gpio.c init_hw.c init_i2c.c init_iodebug.c init_lpm.c init_lpm.h init_lwadc.c init_sai.c init_sci.c init_sdcard.c init_spi.c init_usb.c k22fsh.h mqx_init.c mqx_main.c PE_LDD.h PE_Types.h vectors.c
  group Generic IO Drivers/debug
    ../../../source/io/debug/: iodebug.h iodebug_prv.h iodebug.c iodebug_asm.S
  group Generic IO Drivers/io_mem
    ../../../source/io/io_mem/: io_mem.c io_mem.h iomemprv.h
  group Generic IO Drivers/io_null
    ../../../source/io/io_null/: io_null.c io_null.h ionulprv.h
  group Generic IO Drivers/iopipe
    ../../../source/io/pipe/: io_pipe.c io_pipe.h pipe_prv.h
  group Generic IO Drivers/lpm
    ../../../source/io/lpm/: lpm_kinetis.h lpm_smc.c lpm.h lpm_prv.h lpm.c
  group Peripheral IO Drivers/lwadc
    ../../../source/io/lwadc/: lwadc_k22.c lwadc.h
  group Peripheral IO Drivers/lwadc/kadc
    ../../../source/io/lwadc/: lwadc_kadc.c lwadc_kadc.h lwadc_kadc_prv.h
  group Peripheral IO Drivers/lwgpio/kgpio
    ../../../source/io/lwgpio/: lwgpio_kgpio.c lwgpio_kgpio.h
  group Peripheral IO Drivers/lwgpio
    ../../../source/io/lwgpio/: lwgpio.h lwgpio.c
  group Generic IO Drivers/pcb
    ../../../source/io/pcb/: io_pcb2.c io_pcb.c io_pcb.h iop_inst.c iopcbprv.h
    ../../../source/io/pcb/mqxa/: pcb_mqxa.c pcb_mqxa.h pcbmqxav.h
  group Peripheral IO Drivers/pccard
    ../../../source/io/pccard/: pccardflexbus.h pccardflexbuspr.h pccardflexbus.c apccard.h
  group Peripheral IO Drivers/pcflash
    ../../../source/io/pcflash/: pcflash.h apcflash.c apcflshpr.h ata.h
  group Peripheral IO Drivers/rnga
    ../../../source/io/rnga/: krnga.c rnga.h
  group Peripheral IO Drivers/rtc
    ../../../source/io/rtc/: krtc.h krtc.c rtc.h
  group Peripheral IO Drivers/sai
    ../../../source/io/sai/: sai_mk22.c sai_ksai.h sai_ksai_prv.h sai.h
  group Peripheral IO Drivers/sai/int
    ../../../source/io/sai/int/: sai_int_ksai.c sai_int.c sai_int_prv.h
  group Peripheral IO Drivers/sai/dma
    ../../../source/io/sai/dma/: sai_dma_ksai.c
  group Peripheral IO Drivers/sdcard/sdcard_spi
    ../../../source/io/sdcard/sdcard_spi/: sdcard_spi.c sdcard_spi.h
  group Peripheral IO Drivers/sdcard
    ../../../source/io/sdcard/: sdcard.c sdcard.h sdcard_prv.h
  group Peripheral IO Drivers/serial
    ../../../source/io/serial/: serl_mk22.c serl_kuart.h io_sinit.c serial.h serinprv.h serplprv.h
  group Peripheral IO Drivers/serial/int
    ../../../source/io/serial/int/: serl_int_kuart.c serl_int.c
  group Peripheral IO Drivers/serial/polled
    ../../../source/io/serial/polled/: serl_pol_kuart.c serl_pol.c
  group Peripheral IO Drivers/serial/dma
    ../../../source/io/serial/dma/: serl_dma_kuart.c
  group Peripheral IO Drivers/spi
    ../../../source/io/spi/: spi_mk22_dspi.c spi_dspi_dma.h spi_dspi_dma.c spi_dspi_dma_prv.h spi_dspi_common.h spi_dspi_common.c spi.h spi.c spi_prv.h spi_dspi.h spi_dspi.c spi_dspi_prv.h
  group Generic IO Drivers/tfs
    ../../../source/io/tfs/: tfs.c tfs.h tfs_prv.h
  group Peripheral IO Drivers/timer
    ../../../source/io/timer/: timer_qpit.c timer_kinetis.c timer_qpit.h qpit.h
  group Peripheral IO Drivers/usb
    ../../../source/io/usb/: usb_mk22.c usb_mk22_device.c if_host_ehci.h if_host_khci.h if_dev_ehci.h if_dev_khci.h usb_bsp.h usb_install.c
  group Peripheral IO Drivers/serial/mix
    ../../../source/io/serial/mix/: serl_mix_kuart.c
target bsp_k22fsh Release (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: bsp (library)
  AfterMake: ../../../../mqx/build/bat/bsp_twrk22f120m.bat ../../../.. ../../../../lib/twrk22f120m.uv4/release/bsp uv4 & ".copy.bat" "Release/bsp.lib" "../../../../lib/twrk22f120m.uv4/release/bsp/bsp.lib"
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: ../../../source/io/adc/kadc;../../../source/io/adc;../../../source/io/cm;../../../../config/twrk22f120m;../../../source/io/dma;../../../source/io/flashx/freescale;../../../source/io/flashx;../../../source/io/gpio/kgpio;../../../source/io/gpio;../../../source/io/hwtimer;../../../source/io/i2c;../../../source/io/i2c/polled;../../../source/io/i2c/int;../../../source/bsp/twrk22f120m;../../../../config/common;../../../source/include;../../../source/io/enet;../../../source/io/debug;../../../source/io/io_mem;../../../source/io/io_null;../../../source/io/pipe;../../../source/io/lpm;../../../source/io/lwadc;../../../source/io/lwgpio;../../../source/io/pcb;../../../source/io/pcb/mqxa;../../../source/io/pccard;../../../source/io/pcflash;../../../source/io/rnga;../../../source/io/rtc;../../../source/io/sai;../../../source/io/sai/int;../../../source/io/sdcard/sdcard_spi;../../../source/io/sdcard;../../../source/io/serial;../../../source/io/spi;../../../source/io/tfs;../../../source/io/timer;../../../source/io/usb;../../../source/psp/cortex_m/compiler/rv_uv4;../../../source/psp/cortex_m/cpu;../../../source/psp/cortex_m;../../../source/psp/cortex_m/core/M4;../../../source/tad
  asm misc: --cpreproc 
 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk22f120m.uv4\mqx\intflash.scf
