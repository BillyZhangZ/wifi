# IAR project bsp_k22fsh.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174,Pa050
  ICCARM.CCIncludePath2: ../../../source/io/adc/kadc; ../../../source/io/adc; ../../../source/io/cm; ../../../../config/k22fsh; ../../../source/io/dma; ../../../source/io/enet; ../../../source/io/enet/atheros_wifi; ../../../source/io/enet/atheros_wifi/include; ../../../source/io/enet/atheros_wifi/include/AR6002; ../../../source/io/enet/atheros_wifi/include/AR6002/hw2.0/hw; ../../../source/io/enet/atheros_wifi/include/AR6002/hw4.0/hw; ../../../source/io/enet/atheros_wifi/common_src/include; ../../../source/io/enet/atheros_wifi/common_src/stack_common; ../../../source/io/enet/atheros_wifi/common_src/wmi; ../../../source/io/enet/atheros_wifi/custom_src/include; ../../../source/io/enet/atheros_wifi/custom_src/stack_custom; ../../../source/io/enet/phy; ../../../source/io/flashx/freescale; ../../../source/io/flashx; ../../../source/io/gpio/kgpio; ../../../source/io/gpio; ../../../source/io/hwtimer; ../../../source/io/i2c; ../../../source/io/i2c/polled; ../../../source/io/i2c/int; ../../../source/bsp/k22fsh; ../../../../config/common; ../../../source/include; ../../../source/io/enet; ../../../source/io/debug; ../../../source/io/io_mem; ../../../source/io/io_null; ../../../source/io/pipe; ../../../source/io/lpm; ../../../source/io/lwadc; ../../../source/io/lwgpio; ../../../source/io/pcb; ../../../source/io/pcb/mqxa; ../../../source/io/pccard; ../../../source/io/pcflash; ../../../source/io/rnga; ../../../source/io/rtc; ../../../source/io/sai; ../../../source/io/sai/int; ../../../source/io/sdcard/sdcard_spi; ../../../source/io/sdcard; ../../../source/io/serial; ../../../source/io/spi; ../../../source/io/tfs; ../../../source/io/timer; ../../../source/io/usb; ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m/cpu; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/core/M4; ../../../source/tad; ../../../../mux/source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../source/io/adc/kadc; ../../../source/io/adc; ../../../source/io/cm; ../../../../config/k22fsh; ../../../source/io/dma; ../../../source/io/flashx/freescale; ../../../source/io/flashx; ../../../source/io/gpio/kgpio; ../../../source/io/gpio; ../../../source/io/hwtimer; ../../../source/io/i2c; ../../../source/io/i2c/polled; ../../../source/io/i2c/int; ../../../source/bsp/k22fsh; ../../../../config/common; ../../../source/include; ../../../source/io/enet; ../../../source/io/enet; ../../../source/io/enet/atheros_wifi; ../../../source/io/enet/atheros_wifi/include; ../../../source/io/enet/atheros_wifi/include/AR6002; ../../../source/io/enet/atheros_wifi/include/AR6002/hw2.0/hw; ../../../source/io/enet/atheros_wifi/include/AR6002/hw4.0/hw; ../../../source/io/enet/atheros_wifi/common_src/include; ../../../source/io/enet/atheros_wifi/common_src/stack_common; ../../../source/io/enet/atheros_wifi/common_src/wmi; ../../../source/io/enet/atheros_wifi/custom_src/include; ../../../source/io/enet/atheros_wifi/custom_src/stack_custom; ../../../source/io/enet/phy; ../../../source/io/debug; ../../../source/io/io_mem; ../../../source/io/io_null; ../../../source/io/pipe; ../../../source/io/lpm; ../../../source/io/lwadc; ../../../source/io/lwgpio; ../../../source/io/pcb; ../../../source/io/pcb/mqxa; ../../../source/io/pccard; ../../../source/io/pcflash; ../../../source/io/rnga; ../../../source/io/rtc; ../../../source/io/sai; ../../../source/io/sai/int; ../../../source/io/sdcard/sdcard_spi; ../../../source/io/sdcard; ../../../source/io/serial; ../../../source/io/spi; ../../../source/io/tfs; ../../../source/io/timer; ../../../source/io/usb; ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m/cpu; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/core/M4; ../../../source/tad
  postbuild: ../../../../mqx/build/bat/bsp_k22fsh.bat ../../../.. ../../../../lib/k22fsh.iar/debug/bsp iar
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: ../../../source/io/adc/kadc; ../../../source/io/adc; ../../../source/io/cm; ../../../../config/k22fsh; ../../../source/io/dma; ../../../source/io/flashx/freescale; ../../../source/io/flashx; ../../../source/io/gpio/kgpio; ../../../source/io/gpio; ../../../source/io/hwtimer; ../../../source/io/i2c; ../../../source/io/i2c/polled; ../../../source/io/i2c/int; ../../../source/bsp/k22fsh; ../../../../config/common; ../../../source/include; ../../../source/io/enet; ../../../source/io/enet; ../../../source/io/enet/atheros_wifi; ../../../source/io/enet/atheros_wifi/include; ../../../source/io/enet/atheros_wifi/include/AR6002; ../../../source/io/enet/atheros_wifi/include/AR6002/hw2.0/hw; ../../../source/io/enet/atheros_wifi/include/AR6002/hw4.0/hw; ../../../source/io/enet/atheros_wifi/common_src/include; ../../../source/io/enet/atheros_wifi/common_src/stack_common; ../../../source/io/enet/atheros_wifi/common_src/wmi; ../../../source/io/enet/atheros_wifi/custom_src/include; ../../../source/io/enet/atheros_wifi/custom_src/stack_custom; ../../../source/io/enet/phy; ../../../source/io/debug; ../../../source/io/io_mem; ../../../source/io/io_null; ../../../source/io/pipe; ../../../source/io/lpm; ../../../source/io/lwadc; ../../../source/io/lwgpio; ../../../source/io/pcb; ../../../source/io/pcb/mqxa; ../../../source/io/pccard; ../../../source/io/pcflash; ../../../source/io/rnga; ../../../source/io/rtc; ../../../source/io/sai; ../../../source/io/sai/int; ../../../source/io/sdcard/sdcard_spi; ../../../source/io/sdcard; ../../../source/io/serial; ../../../source/io/spi; ../../../source/io/tfs; ../../../source/io/timer; ../../../source/io/usb; ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m/cpu; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/core/M4; ../../../source/tad; ../../../../mux/source
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: ../../../source/io/adc/kadc; ../../../source/io/adc; ../../../source/io/cm; ../../../../config/k22fsh; ../../../source/io/dma; ../../../source/io/flashx/freescale; ../../../source/io/flashx; ../../../source/io/gpio/kgpio; ../../../source/io/gpio; ../../../source/io/hwtimer; ../../../source/io/i2c; ../../../source/io/i2c/polled; ../../../source/io/i2c/int; ../../../source/bsp/k22fsh; ../../../../config/common; ../../../source/include; ../../../source/io/enet; ../../../source/io/debug; ../../../source/io/io_mem; ../../../source/io/io_null; ../../../source/io/pipe; ../../../source/io/lpm; ../../../source/io/lwadc; ../../../source/io/lwgpio; ../../../source/io/pcb; ../../../source/io/pcb/mqxa; ../../../source/io/pccard; ../../../source/io/pcflash; ../../../source/io/rnga; ../../../source/io/rtc; ../../../source/io/sai; ../../../source/io/sai/int; ../../../source/io/sdcard/sdcard_spi; ../../../source/io/sdcard; ../../../source/io/serial; ../../../source/io/spi; ../../../source/io/tfs; ../../../source/io/timer; ../../../source/io/usb; ../../../source/psp/cortex_m/compiler/iar; ../../../source/psp/cortex_m/cpu; ../../../source/psp/cortex_m; ../../../source/psp/cortex_m/core/M4; ../../../source/tad
  postbuild: ../../../../mqx/build/bat/bsp_k22fsh.bat ../../../.. ../../../../lib/k22fsh.iar/release/bsp iar
  ILINK.IlinkOutputFile: libgeneric.out
  group BSP Files
    ../../../source/bsp/k22fsh/: bsp.h bsp_cm.c bsp_cm.h bsp_prv.h bsp_rev.h init_adc.c init_bsp.c init_dma.c init_enet.c init_flashx.c init_gpio.c init_hw.c init_i2c.c init_iodebug.c init_lpm.c init_lpm.h init_lwadc.c init_sai.c init_sci.c init_sdcard.c init_spi.c init_usb.c k22fsh.h mqx_init.c mqx_main.c PE_LDD.h PE_Types.h vectors.c
    ../../../source/io/enet/: enet.h enet_wifi.h ethernet.h
    ../../../../config/common/: maximum_config.h small_ram_config.h smallest_config.h verif_enabled_config.h
    ../../../source/include/: mqx.h
  group Generic IO Drivers/cm
    ../../../source/io/cm/: cm.c cm.h cm_kinetis.h
  group Generic IO Drivers/debug
    ../../../source/io/debug/: iodebug.c iodebug.h iodebug_asm.S iodebug_prv.h
  group Generic IO Drivers/io_mem
    ../../../source/io/io_mem/: io_mem.c io_mem.h iomemprv.h
  group Generic IO Drivers/io_null
    ../../../source/io/io_null/: io_null.c io_null.h ionulprv.h
  group Generic IO Drivers/iopipe
    ../../../source/io/pipe/: io_pipe.c io_pipe.h pipe_prv.h
  group Generic IO Drivers/lpm
    ../../../source/io/lpm/: lpm.c lpm.h lpm_kinetis.h lpm_prv.h lpm_smc.c
  group Generic IO Drivers/pcb
    ../../../source/io/pcb/: io_pcb.c io_pcb.h io_pcb2.c iop_inst.c iopcbprv.h
    ../../../source/io/pcb/mqxa/: pcb_mqxa.c pcb_mqxa.h pcbmqxav.h
  group Generic IO Drivers/tfs
    ../../../source/io/tfs/: tfs.c tfs.h tfs_prv.h
  group Peripheral IO Drivers/adc
    ../../../source/io/adc/: adc.c adc.h adc_conf.h adc_prv.h
    ../../../source/io/adc/kadc/: adc_mk22.c adc_mk22f.h
  group Peripheral IO Drivers/adc/kadc
    ../../../source/io/adc/kadc/: adc_kadc.c adc_kadc.h adc_kadc_prv.h adt_kpdb.c
  group Peripheral IO Drivers/dma
    ../../../source/io/dma/: dma.c dma.h edma.c edma.h edma_kinetis.c edma_prv.h
  group Peripheral IO Drivers/enet
    ../../../source/io/enet/: enaddr.c enclose.c enerr.c enet_rev.h enetprv.h eninit.c enjoin.c enleave.c enmediactl.c enopen.c enrecv.c ensend.c enstat.c enstop.c enutil.c
  group Peripheral IO Drivers/enet/atheros_wifi
    ../../../source/io/enet/atheros_wifi/: atheros_stack_offload.h atheros_wifi.h atheros_wifi_api.h atheros_wifi_internal.h
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/api_interface
    ../../../source/io/enet/atheros_wifi/common_src/api_interface/: api_init.c api_ioctl.c api_txrx.c api_wmi_rx.c
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/bmi
    ../../../source/io/enet/atheros_wifi/common_src/bmi/: bmi.c
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/driver
    ../../../source/io/enet/atheros_wifi/common_src/driver/: driver_diag.c driver_init.c driver_main.c driver_netbuf.c driver_txrx.c
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/hcd
    ../../../source/io/enet/atheros_wifi/common_src/hcd/: spi_hcd.c
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/htc
    ../../../source/io/enet/atheros_wifi/common_src/htc/: htc.c
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/hw_interface
    ../../../source/io/enet/atheros_wifi/common_src/hw_interface/: hw_api.c
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/include
    ../../../source/io/enet/atheros_wifi/common_src/include/: a_debug.h a_drv.h a_drv_api.h aggr_recv_api.h bmi.h common_api.h dbglog_api.h driver_cxt.h hif_internal.h htc_api.h ieee80211.h netbuf.h spi_hcd_if.h wlan_api.h wmi_api.h
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/reorder
    ../../../source/io/enet/atheros_wifi/common_src/reorder/: rcv_aggr.c
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/stack_common
    ../../../source/io/enet/atheros_wifi/common_src/stack_common/: api_stack_offload.c common_stack_offload.h
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/storerecall
    ../../../source/io/enet/atheros_wifi/common_src/storerecall/: dset.c dset_api.c storerecall.c
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/util
    ../../../source/io/enet/atheros_wifi/common_src/util/: util.c
  group Peripheral IO Drivers/enet/atheros_wifi/common_src/wmi
    ../../../source/io/enet/atheros_wifi/common_src/wmi/: wmi.c wmi_host.h
  group Peripheral IO Drivers/enet/atheros_wifi/custom_src/api_interface
    ../../../source/io/enet/atheros_wifi/custom_src/api_interface/: cust_api_init.c cust_api_ioctl.c cust_api_txrx.c cust_api_wmi_rx.c
  group Peripheral IO Drivers/enet/atheros_wifi/custom_src/driver
    ../../../source/io/enet/atheros_wifi/custom_src/driver/: cust_driver_main.c cust_driver_netbuf.c
  group Peripheral IO Drivers/enet/atheros_wifi/custom_src/hw_interface
    ../../../source/io/enet/atheros_wifi/custom_src/hw_interface/: cust_hw_api.c
  group Peripheral IO Drivers/enet/atheros_wifi/custom_src/include
    ../../../source/io/enet/atheros_wifi/custom_src/include/: a_config.h a_osapi.h a_types.h athendpack.h athstartpack.h cust_context.h cust_netbuf.h custom_api.h wlan_config.h
  group Peripheral IO Drivers/enet/atheros_wifi/custom_src/stack_custom
    ../../../source/io/enet/atheros_wifi/custom_src/stack_custom/: cust_api_stack_offload.c cust_api_stack_txrx.c custom_stack_offload.h
  group Peripheral IO Drivers/enet/atheros_wifi/include
    ../../../source/io/enet/atheros_wifi/include/: athdefs.h bmi_msg.h dbglog.h dbglog_id.h htc.h htc_services.h p2p.h pkt_log.h targaddrs.h wlan_defs.h wmi.h
  group Peripheral IO Drivers/enet/atheros_wifi/include/AR6002
    ../../../source/io/enet/atheros_wifi/include/AR6002/: AR6K_version.h
  group Peripheral IO Drivers/enet/atheros_wifi/include/AR6002/hw2.0/hw
    ../../../source/io/enet/atheros_wifi/include/AR6002/hw2.0/hw/: apb_map.h gpio_reg.h mbox_host_reg.h mbox_reg.h rtc_reg.h si_reg.h uart_reg.h vmc_reg.h
  group Peripheral IO Drivers/enet/atheros_wifi/include/AR6002/hw4.0/hw
    ../../../source/io/enet/atheros_wifi/include/AR6002/hw4.0/hw/: rtc_reg.h rtc_wlan_reg.h
  group Peripheral IO Drivers/enet/phy
    ../../../source/io/enet/phy/: atheros_phy.c atheros_phy.h
  group Peripheral IO Drivers/flashx
    ../../../source/io/flashx/freescale/: flash_mk22.c flash_mk22.h
    ../../../source/io/flashx/: flashx.c flashx.h flashxprv.h
  group Peripheral IO Drivers/flashx/freescale
    ../../../source/io/flashx/freescale/: flash_ftfa.c flash_ftfa.h flash_ftfa_prv.h
  group Peripheral IO Drivers/gpio
    ../../../source/io/gpio/: io_gpio.c io_gpio.h io_gpio_prv.h
  group Peripheral IO Drivers/gpio/knxx
    ../../../source/io/gpio/kgpio/: io_gpio_kgpio.c io_gpio_kgpio.h io_gpio_kgpio_prv.h
  group Peripheral IO Drivers/hwtimer
    ../../../source/io/hwtimer/: hwtimer.c hwtimer.h hwtimer_kinetis.c hwtimer_lpt.c hwtimer_lpt.h hwtimer_pit.c hwtimer_pit.h hwtimer_systick.c hwtimer_systick.h
  group Peripheral IO Drivers/i2c
    ../../../source/io/i2c/: i2c.h i2c_ki2c.h i2c_ki2c_prv.h i2c_mk22.c
    ../../../source/io/i2c/int/: i2c_int_ki2c.c
    ../../../source/io/i2c/polled/: i2c_pol_ki2c.c
  group Peripheral IO Drivers/i2c/int
    ../../../source/io/i2c/int/: i2c_int.c i2c_int_prv.h
  group Peripheral IO Drivers/i2c/polled
    ../../../source/io/i2c/polled/: i2c_pol.c i2c_pol_prv.h
  group Peripheral IO Drivers/lwadc
    ../../../source/io/lwadc/: lwadc.h lwadc_k22.c
  group Peripheral IO Drivers/lwadc/kadc
    ../../../source/io/lwadc/: lwadc_kadc.c lwadc_kadc.h lwadc_kadc_prv.h
  group Peripheral IO Drivers/lwgpio
    ../../../source/io/lwgpio/: lwgpio.c lwgpio.h
  group Peripheral IO Drivers/lwgpio/kgpio
    ../../../source/io/lwgpio/: lwgpio_kgpio.c lwgpio_kgpio.h
  group Peripheral IO Drivers/pccard
    ../../../source/io/pccard/: apccard.h pccardflexbus.c pccardflexbus.h pccardflexbuspr.h
  group Peripheral IO Drivers/pcflash
    ../../../source/io/pcflash/: apcflash.c apcflshpr.h ata.h pcflash.h
  group Peripheral IO Drivers/rnga
    ../../../source/io/rnga/: krnga.c rnga.h
  group Peripheral IO Drivers/rtc
    ../../../source/io/rtc/: krtc.c krtc.h rtc.h
  group Peripheral IO Drivers/sai
    ../../../source/io/sai/: sai.h sai_ksai.h sai_ksai_prv.h sai_mk22.c
  group Peripheral IO Drivers/sai/dma
    ../../../source/io/sai/dma/: sai_dma_ksai.c
  group Peripheral IO Drivers/sai/int
    ../../../source/io/sai/int/: sai_int.c sai_int_ksai.c sai_int_prv.h
  group Peripheral IO Drivers/sdcard
    ../../../source/io/sdcard/: sdcard.c sdcard.h sdcard_prv.h
  group Peripheral IO Drivers/sdcard/sdcard_spi
    ../../../source/io/sdcard/sdcard_spi/: sdcard_spi.c sdcard_spi.h
  group Peripheral IO Drivers/serial
    ../../../source/io/serial/: io_sinit.c serial.h serinprv.h serl_kuart.h serl_mk22.c serplprv.h
  group Peripheral IO Drivers/serial/dma
    ../../../source/io/serial/dma/: serl_dma_kuart.c
  group Peripheral IO Drivers/serial/int
    ../../../source/io/serial/int/: serl_int.c serl_int_kuart.c
  group Peripheral IO Drivers/serial/mix
    ../../../source/io/serial/mix/: serl_mix_kuart.c
  group Peripheral IO Drivers/serial/polled
    ../../../source/io/serial/polled/: serl_pol.c serl_pol_kuart.c
  group Peripheral IO Drivers/spi
    ../../../source/io/spi/: spi.c spi.h spi_dspi.c spi_dspi.h spi_dspi_common.c spi_dspi_common.h spi_dspi_dma.c spi_dspi_dma.h spi_dspi_dma_prv.h spi_dspi_prv.h spi_mk22_dspi.c spi_prv.h
  group Peripheral IO Drivers/timer
    ../../../source/io/timer/: qpit.h timer_kinetis.c timer_qpit.c timer_qpit.h
  group Peripheral IO Drivers/usb
    ../../../source/io/usb/: if_dev_ehci.h if_dev_khci.h if_host_ehci.h if_host_khci.h usb_bsp.h usb_install.c usb_mk22.c usb_mk22_device.c
  group User Config
    ../../../../config/k22fsh/: user_config.h
