# IAR project dev_audio_speaker_twrk22f120m.ewp, settings and files
configuration Int Flash Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22DN512xxx5 Freescale MK22DN512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CPU_MK22F51212=1; _DEBUG=1
  ICCARM.CCDiagSuppress: Pe223,Pe021,Pe375,Pa082
  ICCARM.CCIncludePath2: ../../..; ../..; ../../../../../../../output/twrk22f120m.iar/debug/usbd/mqx; ../../../../../../../../lib/twrk22f120m.iar/debug/bsp/Generated_Code; ../../../../../../../../lib/twrk22f120m.iar/debug/bsp/Sources; ../../../../../../../../lib/twrk22f120m.iar/debug; ../../../../../../../../lib/twrk22f120m.iar/debug/bsp; ../../../../../../../../lib/twrk22f120m.iar/debug/psp
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: twrk22f120m.srec
  ILINK.IlinkOutputFile: dev_audio_speaker.out
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk22f120m.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk22f120m.iar/debug/usbd/mqx/usbd.a; ../../../../../../../../lib/twrk22f120m.iar/debug/bsp/bsp.a; ../../../../../../../../lib/twrk22f120m.iar/debug/psp/psp.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK22F51212=1
  ICCARM.CCIncludePath2: ../../..; ../..; ../../../../../../../output/twrk22f120m.iar/release/usbd/mqx; ../../../../../../../../lib/twrk22f120m.iar/release/bsp/Generated_Code; ../../../../../../../../lib/twrk22f120m.iar/release/bsp/Sources; ../../../../../../../../lib/twrk22f120m.iar/release; ../../../../../../../../lib/twrk22f120m.iar/release/bsp; ../../../../../../../../lib/twrk22f120m.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk22f120m.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../../../output/twrk22f120m.iar/release/usbd/mqx/usbd.a; ../../../../../../../../lib/twrk22f120m.iar/release/bsp/bsp.a; ../../../../../../../../lib/twrk22f120m.iar/release/psp/psp.a
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CPU_MK22F51212=1
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ../../../../../../../../lib/twrk22f120m.iar/release/bsp/ram.icf
  ILINK.IlinkAdditionalLibs: as above
  group Sources/app
    ../../../: audio_speaker.c audio_speaker.h usb_request.c usb_request.h usb_descriptor.c usb_descriptor.h
    ../../: sgtl5000.c sgtl5000.h
