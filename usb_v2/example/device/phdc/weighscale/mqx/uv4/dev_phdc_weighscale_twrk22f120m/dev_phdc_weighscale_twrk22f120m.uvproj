# Keil uVision project dev_phdc_weighscale_twrk22f120m.uvproj, settings and files
target dev_phdc_weighscale_twrk22f120m Int Flash Debug (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: dev_phdc_weighscale +hex
  c flags: Optim=1 OneElfS=1
  c define: CPU_MK22F51212=1, _DEBUG=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: ../../..;../../../../../../../output/twrk22f120m.uv4/debug/usbd/mqx;../../../../../../../../lib/twrk22f120m.uv4/debug/bsp/Generated_Code;../../../../../../../../lib/twrk22f120m.uv4/debug/bsp/Sources;../../../../../../../../lib/twrk22f120m.uv4/debug;../../../../../../../../lib/twrk22f120m.uv4/debug/bsp;../../../../../../../../lib/twrk22f120m.uv4/debug/psp
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ../../../../../../../../lib/twrk22f120m.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../../../output/twrk22f120m.uv4/debug/usbd/mqx/usbd.lib

../../../../../../../../lib/twrk22f120m.uv4/debug/bsp/bsp.lib

../../../../../../../../lib/twrk22f120m.uv4/debug/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/twrk22f120m.uv4/debug/psp/psp.lib

../../../../../../../../lib/twrk22f120m.uv4/debug/psp/psp.lib(linker_symbols.o)

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=L6314W 

 --remove 

 --autoat
  group Sources/app
    ../../../: phd_com_model.c phd_com_model.h weighscale.c weighscale.h ieee11073_nom_codes.h ieee11073_phd_types.h usb_descriptor.c usb_descriptor.h
target dev_phdc_weighscale_twrk22f120m Int Flash Release (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: as above
  output: dev_phdc_weighscale +hex
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK22F51212=1
  c misc: as above
  c include: ../../..;../../../../../../../output/twrk22f120m.uv4/release/usbd/mqx;../../../../../../../../lib/twrk22f120m.uv4/release/bsp/Generated_Code;../../../../../../../../lib/twrk22f120m.uv4/release/bsp/Sources;../../../../../../../../lib/twrk22f120m.uv4/release;../../../../../../../../lib/twrk22f120m.uv4/release/bsp;../../../../../../../../lib/twrk22f120m.uv4/release/psp
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  scatter file: ../../../../../../../../lib/twrk22f120m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../../output/twrk22f120m.uv4/release/usbd/mqx/usbd.lib

../../../../../../../../lib/twrk22f120m.uv4/release/bsp/bsp.lib

../../../../../../../../lib/twrk22f120m.uv4/release/bsp/bsp.lib(vectors.o)

../../../../../../../../lib/twrk22f120m.uv4/release/psp/psp.lib

../../../../../../../../lib/twrk22f120m.uv4/release/psp/psp.lib(linker_symbols.o)

 --keep linker_symbols.o(KERNEL_DATA_START) 

 --keep linker_symbols.o(KERNEL_DATA_END) 

 --keep linker_symbols.o(BOOT_STACK) 

 --keep vectors.o(.vectors_rom) 

 --diag_suppress=L6314W 

 --remove 

 --autoat
