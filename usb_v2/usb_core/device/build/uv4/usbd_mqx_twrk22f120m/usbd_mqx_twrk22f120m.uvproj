# Keil uVision project usbd_mqx_twrk22f120m.uvproj, settings and files
target usbd_mqx_twrk22f120m Debug (ARM-ADS)
  device: MK22FN512xxx10 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: usbd (library)
  AfterMake: ../../../../../usb_core/device/build/bat/usbd_twrk22f120m.bat ../../../../.. ../../../../../output/twrk22f120m.uv4/debug/usbd/mqx uv4 mqx & ".copy.bat" "Debug/usbd.lib" "../../../../../output/twrk22f120m.uv4/debug/usbd/mqx/usbd.lib"
  c flags: Optim=1 OneElfS=1
  c define: CPU_MK22F51212=1, _DEBUG=1
  c misc: --library_interface=armcc   --library_type=standardlib  --c99  --diag_suppress=223,375
  c include: ../../../../../adapter/sources;../../../../../adapter/sources/mqx;../../../../hal;../../../include/twrk22f120m;../../../include;../../../sources/classes/audio;../../../sources/classes/cdc;../../../sources/classes/common;../../../sources/classes/composite;../../../sources/classes/hid;../../../sources/classes/include;../../../sources/classes/msd;../../../sources/classes/phdc;../../../sources/controller;../../../sources/controller/khci;../../../../include;../../../../../../lib/twrk22f120m.uv4/debug/bsp/Generated_Code;../../../../../../lib/twrk22f120m.uv4/debug/bsp/Sources;../../../../../../lib/twrk22f120m.uv4/debug;../../../../../../lib/twrk22f120m.uv4/debug/bsp;../../../../../../lib/twrk22f120m.uv4/debug/psp
  asm define: _DEBUG=1
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk22f120m.uv4\mqx\intflash.scf
  group adapter
    ../../../../../adapter/sources/: adapter.h adapter_types.h
    ../../../../../adapter/sources/mqx/: adapter_mqx.c adapter_mqx.h adapter_cfg.h
  group hal
    ../../../../hal/: fsl_usb_khci_hal.h
  group usb_core/device/include
    ../../../include/twrk22f120m/: usb_device_config.h
    ../../../include/: usb_device_stack_interface.h
  group usb_core/device/sources/bsp
    ../../../sources/bsp/twrk22f120m/: usb_dev_bsp.c
  group usb_core/device/sources/class driver/audio
    ../../../sources/classes/audio/: usb_audio.c usb_audio.h
  group usb_core/device/sources/class driver/cdc
    ../../../sources/classes/cdc/: usb_cdc_pstn.c usb_cdc_pstn.h usb_cdc.c usb_cdc.h
  group usb_core/device/sources/class driver/common
    ../../../sources/classes/common/: usb_class.c usb_class_internal.h
  group usb_core/device/sources/class driver/composite
    ../../../sources/classes/composite/: usb_composite.c usb_composite.h
  group usb_core/device/sources/class driver/hid
    ../../../sources/classes/hid/: usb_hid.c usb_hid.h
  group usb_core/device/sources/class driver/include
    ../../../sources/classes/include/: usb_class_audio.h usb_class_cdc.h usb_class_composite.h usb_class_hid.h usb_class_msc.h usb_class_phdc.h usb_class.h
  group usb_core/device/sources/class driver/msd
    ../../../sources/classes/msd/: usb_msc_scsi.c usb_msc_scsi.h usb_msc.c usb_msc.h
  group usb_core/device/sources/class driver/phdc
    ../../../sources/classes/phdc/: usb_phdc.c usb_phdc.h
  group usb_core/device/sources/controller driver
    ../../../sources/controller/: khci_interface.c usb_dev.c usb_dev.h usb_framework.c usb_framework.h
  group usb_core/device/sources/controller driver/khci
    ../../../sources/controller/khci/: khci_dev_misc.h khci_dev.c khci_dev.h
  group usb_core/include
    ../../../../include/: compiler.h types.h usb_desc.h usb_error.h usb_misc.h usb_opt.h usb_types.h
target usbd_mqx_twrk22f120m Release (ARM-ADS)
  device: MK22FN512xxx10 Freescale Semiconductor
  cpu: as above
  output: usbd (library)
  AfterMake: ../../../../../usb_core/device/build/bat/usbd_twrk22f120m.bat ../../../../.. ../../../../../output/twrk22f120m.uv4/release/usbd/mqx uv4 mqx & ".copy.bat" "Release/usbd.lib" "../../../../../output/twrk22f120m.uv4/release/usbd/mqx/usbd.lib"
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK22F51212=1
  c misc: as above
  c include: ../../../../../adapter/sources;../../../../../adapter/sources/mqx;../../../../hal;../../../include/twrk22f120m;../../../include;../../../sources/classes/audio;../../../sources/classes/cdc;../../../sources/classes/common;../../../sources/classes/composite;../../../sources/classes/hid;../../../sources/classes/include;../../../sources/classes/msd;../../../sources/classes/phdc;../../../sources/controller;../../../sources/controller/khci;../../../../include;../../../../../../lib/twrk22f120m.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk22f120m.uv4/release/bsp/Sources;../../../../../../lib/twrk22f120m.uv4/release;../../../../../../lib/twrk22f120m.uv4/release/bsp;../../../../../../lib/twrk22f120m.uv4/release/psp
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk22f120m.uv4\mqx\intflash.scf
