# IAR project sensors_k22fsh.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FX512xxx12 Freescale MK22FX512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../source; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../bluetooth/lib; ../../../../audio/include; ../../../../msi/source/; ../../../../shell/source/include; ../../../../mqx/source/io/cm; ../../../../config/k22fsh; ../../../../mqx/source/io/dma; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/bsp/k22fsh; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/lwadc; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/rnga; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/sai/int; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/usb; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/tad; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mfs/source/include; ../../../../mux/source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../source; ../../../../mqx/source/io/adc/kadc; ../../../../mqx/source/io/adc; ../../../../bluetooth/lib; ../../../../audio/include; ../../../../msi/source/; ../../../../shell/source/include; ../../../../mqx/source/io/cm; ../../../../config/k22fsh; ../../../../mqx/source/io/dma; ../../../../mqx/source/io/flashx/freescale; ../../../../mqx/source/io/flashx; ../../../../mqx/source/io/gpio/kgpio; ../../../../mqx/source/io/gpio; ../../../../mqx/source/io/hwtimer; ../../../../mqx/source/io/i2c; ../../../../mqx/source/io/i2c/polled; ../../../../mqx/source/io/i2c/int; ../../../../mqx/source/bsp/k22fsh; ../../../../config/common; ../../../../mqx/source/include; ../../../../mqx/source/io/enet; ../../../../mqx/source/io/debug; ../../../../mqx/source/io/io_mem; ../../../../mqx/source/io/io_null; ../../../../mqx/source/io/pipe; ../../../../mqx/source/io/lpm; ../../../../mqx/source/io/lwadc; ../../../../mqx/source/io/lwgpio; ../../../../mqx/source/io/pcb; ../../../../mqx/source/io/pcb/mqxa; ../../../../mqx/source/io/pccard; ../../../../mqx/source/io/pcflash; ../../../../mqx/source/io/rnga; ../../../../mqx/source/io/rtc; ../../../../mqx/source/io/sai; ../../../../mqx/source/io/sai/int; ../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../mqx/source/io/sdcard; ../../../../mqx/source/io/serial; ../../../../mqx/source/io/spi; ../../../../mqx/source/io/tfs; ../../../../mqx/source/io/timer; ../../../../mqx/source/io/usb; ../../../../mqx/source/psp/cortex_m/cpu; ../../../../mqx/source/psp/cortex_m; ../../../../mqx/source/psp/cortex_m/core/M4; ../../../../mqx/source/tad; ../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../mfs/source/include
  postbuild: ../../../../sensors/build/bat/sensors_k22fsh.bat ../../../.. ../../../../lib/k22fsh.iar/debug/sensors iar
  ILINK.IlinkOutputFile: player_twrk22f120m.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  postbuild: ../../../../sensors/build/bat/sensors_k22fsh.bat ../../../.. ../../../../lib/k22fsh.iar/release/sensors iar
  ILINK.IlinkOutputFile: lcd_k22fsh.out
  group source
    ../../../source/: fxas21002.c fxas21002.h i2c_common.c i2c_common.h mag3110.c mag3110.h mma8653.c mma8653.h pm25table.h pm2p5.c pm2p5.h sensors.h sht25.c sht25.h
