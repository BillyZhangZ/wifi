<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\mqx\build\iar\bsp_k22fsh\bsp_k22fsh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\lcd\build\iar\lcd_k22fsh\lcd_k22fsh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\mfs\build\iar\mfs_k22fsh\mfs_k22fsh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\mux\build\iar\mux_k22fsh\mux_k22fsh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\mqx\build\iar\psp_k22fsh\psp_k22fsh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\rtcs\build\iar\rtcs_k22fsh\rtcs_k22fsh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\sensors\build\iar\sensors_k22fsh\sensors_k22fsh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\shell\build\iar\shell_k22fsh\shell_k22fsh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\test_k22fsh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\demo\throughput_demo\build\iar\k22fsh\throughput_demo_k22fsh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\build\iar\unit_test_k22fsh\unit_test_k22fsh.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\usb\host\build\iar\k22fsh\usb_k22fsh.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>mqx_core</name>
      <member>
        <project>bsp_k22fsh</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bsp_k22fsh</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_k22fsh</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_k22fsh</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_k22fsh</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_k22fsh</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>usb_k22fsh</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>usb_k22fsh</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


