# IAR project test_k22fsh.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: UNIT_TEST_BASEBOARD=1
  ICCARM.CCIncludePath2: ../../../../lib/k22fsh.iar/debug/bsp/Generated_Code; ../../../../lib/k22fsh.iar/debug/bsp/Sources; ../../../../lib/k22fsh.iar/debug; ../../../../lib/k22fsh.iar/debug/bsp; ../../../../lib/k22fsh.iar/debug/psp; ../../../../lib/k22fsh.iar/debug/shell; ../../../../lib/k22fsh.iar/debug/bluetooth; ../../../../lib/k22fsh.iar/debug/usb; ../../../../lib/k22fsh.iar/debug/msi; ../../../../lib/k22fsh.iar/debug/mfs; ../../../../lib/k22fsh.iar/debug/lcd; ../../../../lib/k22fsh.iar/debug/player; ../../../../unit_test/source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../../../usb/host/source; ../../../../../player/source; ../../../../../audio/include; ../../../../../audio/include/source; ../../../../../usb/host/source/include; ../../../../../usb/common/include; ../../../../../usb/host/source/include; ../../../../../usb/host/source/classes/audio; ../../../../../usb/host/source/classes/aoap; ../../../../../usb/host/source/host/ehci; ../../../../../usb/host/source/classes/bluetooth; ../../../../../usb/host/source/classes/cdc; ../../../../../usb/host/source/classes/hid; ../../../../../usb/host/source/classes/hub; ../../../../../usb/host/source/classes/msd; ../../../../../usb/host/source/classes/msd/mfs; ../../../../../usb/host/source/classes/phdc; ../../../../../usb/host/source/classes/printer; ../../../../../usb/host/source/rtos/mqx; ../../../../../mqx/source/io/adc/kadc; ../../../../../bluetooth/Lib; ../../../../../shell/source/include; ../../../../../bluetooth/Lib/aac; ../../../../../bluetooth/Lib; ../../../../../audio/include; ../../../../../msi/source/; ../../../../../mqx/source/io/adc; ../../../../../mqx/source/io/cm; ../../../../../config/k22fsh; ../../../../../mqx/source/io/dma; ../../../../../mqx/source/io/flashx/freescale; ../../../../../mqx/source/io/flashx; ../../../../../mqx/source/io/gpio/kgpio; ../../../../../mqx/source/io/gpio; ../../../../../mqx/source/io/hwtimer; ../../../../../mqx/source/io/i2c; ../../../../../mqx/source/io/i2c/polled; ../../../../../mqx/source/io/i2c/int; ../../../../../mqx/source/bsp/k22fsh; ../../../../../config/common; ../../../../../mqx/source/include; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/debug; ../../../../../mqx/source/io/io_mem; ../../../../../mqx/source/io/io_null; ../../../../../mqx/source/io/pipe; ../../../../../mqx/source/io/lpm; ../../../../../mqx/source/io/lwadc; ../../../../../mqx/source/io/lwgpio; ../../../../../mqx/source/io/pcb; ../../../../../mqx/source/io/pcb/mqxa; ../../../../../mqx/source/io/pccard; ../../../../../mqx/source/io/pcflash; ../../../../../mqx/source/io/rnga; ../../../../../mqx/source/io/rtc; ../../../../../mqx/source/io/sai; ../../../../../mqx/source/io/sai/int; ../../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../../mqx/source/io/sdcard; ../../../../../mqx/source/io/serial; ../../../../../mqx/source/io/spi; ../../../../../mqx/source/io/tfs; ../../../../../mqx/source/io/timer; ../../../../../mqx/source/io/usb; ../../../../../mqx/source/psp/cortex_m/cpu; ../../../../../mqx/source/psp/cortex_m; ../../../../../mqx/source/psp/cortex_m/core/M4; ../../../../../mqx/source/tad; ../../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../mfs/source/include
  OBJCOPY.OOCOutputFile: test_k22fsh.bin
  ILINK.IlinkOutputFile: test_k22fsh.out
  ILINK.IlinkIcfFile: ../../../../lib/k22fsh.iar/debug/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/k22fsh.iar/debug/bsp/bsp.a; ../../../../lib/k22fsh.iar/debug/psp/psp.a; ../../../../lib/k22fsh.iar/debug/shell/shell.a; ../../../../lib/k22fsh.iar/debug/mfs/mfs.a; ../../../../lib/k22fsh.iar/debug/mux/mux.a; ../../../../lib/k22fsh.iar/debug/unit_test/unit_test.a; ../../../../lib/k22fsh.iar/debug/usb/usb_k22fsh.a; ../../../../lib/k22fsh.iar/debug/lcd/lcd.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK22FN256xxx12 Freescale MK22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../../../lib/k22fsh.iar/release/bsp/Generated_Code; ../../../../lib/k22fsh.iar/release/bsp/Sources; ../../../../lib/k22fsh.iar/release; ../../../../lib/k22fsh.iar/release/bsp; ../../../../lib/k22fsh.iar/release/psp; ../../../../lib/k22fsh.iar/release/shell; ../../../../lib/k22fsh.iar/release/bluetooth; ../../../../lib/k22fsh.iar/release/usb; ../../../../lib/k22fsh.iar/release/msi; ../../../../lib/k22fsh.iar/release/mfs; ../../../../lib/k22fsh.iar/release/lcd; ../../../../lib/k22fsh.iar/release/player; ../../../../unit_test/source
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: test_k22fsh.srec
  ILINK.IlinkIcfFile: ../../../../lib/k22fsh.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/k22fsh.iar/release/bsp/bsp.a; ../../../../lib/k22fsh.iar/release/psp/psp.a; ../../../../lib/k22fsh.iar/release/shell/shell.a; ../../../../lib/k22fsh.iar/release/mfs/mfs.a; ../../../../lib/k22fsh.iar/release/mux/mux.a; ../../../../lib/k22fsh.iar/release/unit_test/unit_test.a; ../../../../lib/k22fsh.iar/release/usb/usb_k22fsh.a; ../../../../lib/k22fsh.iar/release/lcd/lcd.a
  group source
    ../../source/: main.c main.h
