<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\bsp_twrk22_qca4002\bsp_twrk22_qca4002.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mfs\build\iar\mfs_twrk22_qca4002\mfs_twrk22_qca4002.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\psp_twrk22_qca4002\psp_twrk22_qca4002.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\rtcs\build\iar\rtc_twrk22_qca4002\rtcs_twrk22_qca4002.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\shell\build\iar\shell_twrk22_qca4002\shell_twrk22_qca4002.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\demo\throughput_demo\build\iar\throughput_twrk22_qca4002\throughput_twrk22_qca4002.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>bsp_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bsp_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>bsp_twrk22_qca4002</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_twrk22_qca4002</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk22_qca4002</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_twrk22_qca4002</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rtcs_twrk22_qca4002</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>bsp_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


