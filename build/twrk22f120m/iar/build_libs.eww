<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\bsp_twrk22f120m\bsp_twrk22f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mfs\build\iar\mfs_twrk22f120m\mfs_twrk22f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\mqx\build\iar\psp_twrk22f120m\psp_twrk22f120m.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\shell\build\iar\shell_twrk22f120m\shell_twrk22f120m.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>bsp_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>bsp_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Debug</name>
      <member>
        <project>bsp_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mfs_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>psp_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>shell_twrk22f120m</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>Release</name>
      <member>
        <project>bsp_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>mfs_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>psp_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
      <member>
        <project>shell_twrk22f120m</project>
        <configuration>Release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


