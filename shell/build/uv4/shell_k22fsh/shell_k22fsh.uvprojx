# Keil uVision project shell_k22fsh.uvprojx, settings and files
target shell_k22fsh Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: shell (library)
  AfterMake: ../../../../shell/build/bat/shell_k22fsh.bat ../../../.. ../../../../lib/k22fsh.uv4/debug/shell uv4 & ".copy.bat" "Debug/shell.lib" "../../../../lib/k22fsh.uv4/debug/shell/shell.lib"
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 
 --library_type=standardlib 
--c99
 --diag_suppress=1296,186
  c include: ../../../source/include;../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/adc;../../../../mqx/source/io/cm;../../../../config/k22fsh;../../../../mqx/source/io/dma;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/flashx;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/gpio;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/i2c;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/i2c/int;../../../../mqx/source/bsp/k22fsh;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/io/enet;../../../../mqx/source/io/debug;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/io_null;../../../../mqx/source/io/pipe;../../../../mqx/source/io/lpm;../../../../mqx/source/io/lwadc;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/pcb;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/pccard;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/rnga;../../../../mqx/source/io/rtc;../../../../mqx/source/io/sai;../../../../mqx/source/io/sai/int;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/serial;../../../../mqx/source/io/spi;../../../../mqx/source/io/tfs;../../../../mqx/source/io/timer;../../../../mqx/source/io/usb;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/core/M4;../../../../mqx/source/tad;../../../../mfs/source/include;../../../../rtcs/source/include
  asm define: _DEBUG=1
  asm misc: --cpreproc 
 --diag_suppress=1609,1581
  asm include: ../../../source/include;../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/adc;../../../../mqx/source/io/cm;../../../../config/k22fsh;../../../../mqx/source/io/dma;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/flashx;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/gpio;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/i2c;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/i2c/int;../../../../mqx/source/bsp/k22fsh;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/io/enet;../../../../mqx/source/io/debug;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/io_null;../../../../mqx/source/io/pipe;../../../../mqx/source/io/lpm;../../../../mqx/source/io/lwadc;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/pcb;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/pccard;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/rnga;../../../../mqx/source/io/rtc;../../../../mqx/source/io/sai;../../../../mqx/source/io/sai/int;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/serial;../../../../mqx/source/io/spi;../../../../mqx/source/io/tfs;../../../../mqx/source/io/timer;../../../../mqx/source/io/usb;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/core/M4;../../../../mqx/source/tad;../../../../mfs/source/include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\..\lib\k22fsh.uv4\debug\bsp\intflash.scf
  group Shell Source/mfs
    ../../../source/mfs/: sh_cache.c sh_cd.c sh_compare.c sh_copy.c sh_create.c sh_del.c sh_df.c sh_di.c sh_dir.c sh_dirent.c sh_disect.c sh_flush.c sh_format.c sh_mkdir.c sh_pwd.c sh_read.c sh_readtest.c sh_rename.c sh_rmdir.c sh_type.c sh_write.c sh_writetest.c
    ../../../source/include/: sh_mfs.h
  group Shell Source/mqx
    ../../../source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
    ../../../source/include/: sh_prv.h shell.h
  group Shell Source/rtcs
    ../../../source/rtcs/: sh_arpdisp.c sh_clock.c sh_echod.c sh_eds.c sh_enet.c sh_exec.c sh_ftpc.c sh_ftpd.c sh_gate.c sh_getroute.c sh_ghbn.c sh_ipconfig.c sh_iwconfig.c sh_load.c sh_nat.c sh_nstat.c sh_ping.c sh_ppp.c sh_rtcs.c sh_sendto.c sh_smtp.c sh_snmpd.c sh_tftp.c sh_tftpd.c sh_tnet.c sh_tnetd.c
  group Shell Source/shell
    ../../../source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
    ../../../source/include/: sh_rtcs.h sh_enet.h
target shell_k22fsh Release (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: shell (library)
  AfterMake: ../../../../shell/build/bat/shell_twrk22f120m.bat ../../../.. ../../../../lib/twrk22f120m.uv4/release/shell uv4 & ".copy.bat" "Release/shell.lib" "../../../../lib/twrk22f120m.uv4/release/shell/shell.lib"
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: ../../../source/include;../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/adc;../../../../mqx/source/io/cm;../../../../config/twrk22f120m;../../../../mqx/source/io/dma;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/flashx;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/gpio;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/i2c;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/i2c/int;../../../../mqx/source/bsp/twrk22f120m;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/io/enet;../../../../mqx/source/io/debug;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/io_null;../../../../mqx/source/io/pipe;../../../../mqx/source/io/lpm;../../../../mqx/source/io/lwadc;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/pcb;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/pccard;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/rnga;../../../../mqx/source/io/rtc;../../../../mqx/source/io/sai;../../../../mqx/source/io/sai/int;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/serial;../../../../mqx/source/io/spi;../../../../mqx/source/io/tfs;../../../../mqx/source/io/timer;../../../../mqx/source/io/usb;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/core/M4;../../../../mqx/source/tad;../../../../mfs/source/include
  asm misc: --cpreproc 
 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk22f120m.uv4\mqx\intflash.scf
