# Keil uVision project glucose_demo_k22fsh.uvprojx, settings and files
target ble_demo_k22fsh Int Flash Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: glucose_demo +hex
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 
 --library_type=standardlib 
--c99
 --diag_suppress=1296,186
  c include: ../../..;../../../source/Application;../../../source/K22_Driver;../../../source/Porting_Interfaces;../../../source/Interfaces;../../../source/Interfaces/ATT;../../../source/Interfaces/Services;../../../../../lib/k22fsh.uv4/debug/bsp/Generated_Code;../../../../../lib/k22fsh.uv4/debug/bsp/Sources;../../../../../lib/k22fsh.uv4/debug;../../../../../lib/k22fsh.uv4/debug/bsp;../../../../../lib/k22fsh.uv4/debug/psp;../../../../../lib/k22fsh.uv4/debug/mux
  asm define: _DEBUG=1
  asm misc: --cpreproc 
 --diag_suppress=1609,1581
  asm include: ../../..
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ../../../../../lib/k22fsh.uv4/debug/bsp/intflash.scf
  link misc: ../../../../../lib/k22fsh.uv4/debug/bsp/bsp.lib
../../../../../lib/k22fsh.uv4/debug/bsp/bsp.lib(vectors.o)
../../../../../lib/k22fsh.uv4/debug/psp/psp.lib
../../../../../lib/k22fsh.uv4/debug/psp/psp.lib(linker_symbols.o)
../../../../../lib/k22fsh.uv4/debug/mux/mux.lib
 --keep linker_symbols.o(KERNEL_DATA_START) 
 --keep linker_symbols.o(KERNEL_DATA_END) 
 --keep linker_symbols.o(BOOT_STACK) 
 --keep vectors.o(.vectors_rom) 
 --diag_suppress=6314,6329 
 --remove 
 --autoat
  group Application
    ../../../source/Application/: BleApp.c BleApp.h BleGlucose_Sensor.h glucose_app.c glucose_app.h main.c
  group K22_Driver
    ../../../source/K22_Driver/: adc_pin.h
  group K22_Intergration
    ../../../source/Porting_Interfaces/: BLECustomConfig.h K22_EM9301_Radio.c K22_Hci_Spi.c K22_System.c spi_prv.h
  group Ble_Libs
    ../../../source/Application/: BLESW_GLP_Sensor_CM3.lib
    ../../../source/Libraries/: BLESW_CoreStack_CM3.lib BLESW_DIS_CM3.lib BLESW_GLS_CM3.lib
target ble_demo_k22fsh Int Flash Release (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: spi +hex
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: ../../..;../../../../../../lib/twrk22f120m.uv4/release/bsp/Generated_Code;../../../../../../lib/twrk22f120m.uv4/release/bsp/Sources;../../../../../../lib/twrk22f120m.uv4/release;../../../../../../lib/twrk22f120m.uv4/release/bsp;../../../../../../lib/twrk22f120m.uv4/release/psp
  asm misc: --cpreproc 
 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ../../../../../../lib/twrk22f120m.uv4/release/bsp/intflash.scf
  link misc: ../../../../../../lib/twrk22f120m.uv4/release/bsp/bsp.lib
../../../../../../lib/twrk22f120m.uv4/release/bsp/bsp.lib(vectors.o)
../../../../../../lib/twrk22f120m.uv4/release/psp/psp.lib
../../../../../../lib/twrk22f120m.uv4/release/psp/psp.lib(linker_symbols.o)
 --keep linker_symbols.o(KERNEL_DATA_START) 
 --keep linker_symbols.o(KERNEL_DATA_END) 
 --keep linker_symbols.o(BOOT_STACK) 
 --keep vectors.o(.vectors_rom) 
 --diag_suppress=6314,6329 
 --remove 
 --autoat
