# IAR project utf_agent.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN1M0xxx12 Freescale MK22FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCIncludePath2: ../../../mqx/source/io/enet; ../../../mqx/source/io/enet/atheros_wifi; ../../../mqx/source/io/enet/atheros_wifi/include; ../../../mqx/source/io/enet/atheros_wifi/include/AR6002; ../../../mqx/source/io/enet/atheros_wifi/include/AR6002/hw2.0; ../../../mqx/source/io/enet/atheros_wifi/common_src/include; ../../../mqx/source/io/enet/atheros_wifi/custom_src/include; ../../../demo/utf_agent/src; ../../../rtcs/source/include; ../../../shell/source/include; ../../../lib/sp140k22f.iar/debug/psp; ../../../lib/sp140k22f.iar/debug/bsp/Sources; ../../../lib/sp140k22f.iar/debug/bsp/Generated_Code; ../../../lib/sp140k22f.iar/debug/bsp; ../../../lib/sp140k22f.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../../../lib/sp140k22f.iar/debug/psp; ../../../lib/sp140k22f.iar/debug/bsp/Sources; ../../../lib/sp140k22f.iar/debug/bsp/Generated_Code; ../../../lib/sp140k22f.iar/debug/bsp; ../../../lib/sp140k22f.iar/debug
  OBJCOPY.OOCOutputFile: utf_agent.bin
  ILINK.IlinkOutputFile: utf_agent.out
  ILINK.IlinkIcfFile: ../../../lib/sp140k22f.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../lib/sp140k22f.iar/debug/bsp/bsp.a; ../../../lib/sp140k22f.iar/debug/mfs/mfs.a; ../../../lib/sp140k22f.iar/debug/psp/psp.a; ../../../lib/sp140k22f.iar/debug/rtcs/rtcs.a; ../../../lib/sp140k22f.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../../mqx/source/io/enet; ../../../mqx/source/io/enet/atheros_wifi; ../../../mqx/source/io/enet/atheros_wifi/include; ../../../mqx/source/io/enet/atheros_wifi/include/AR6002; ../../../mqx/source/io/enet/atheros_wifi/include/AR6002/hw2.0; ../../../mqx/source/io/enet/atheros_wifi/common_src/include; ../../../mqx/source/io/enet/atheros_wifi/custom_src/include; ../../../demo/utf_agent/src; ../../../rtcs/source/include; ../../../shell/source/include; ../../../lib/sp140k22f.iar/release/psp; ../../../lib/sp140k22f.iar/release/bsp/Sources; ../../../lib/sp140k22f.iar/release/bsp/Generated_Code; ../../../lib/sp140k22f.iar/release/bsp; ../../../lib/sp140k22f.iar/release
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  ILINK.IlinkIcfFile: ../../../lib/sp140k22f.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../lib/sp140k22f.iar/release/bsp/bsp.a; ../../../lib/sp140k22f.iar/release/mfs/mfs.a; ../../../lib/sp140k22f.iar/release/psp/psp.a; ../../../lib/sp140k22f.iar/release/rtcs/rtcs.a; ../../../lib/sp140k22f.iar/release/shell/shell.a
  group Source/driver_plugin
    ../driver_plugin/: atheros_driver_plugin.h atheros_wifi_init.c atheros_wifi_mediactl_ext.c atheros_wifi_raw_if.c
  group Source/src
    ../src/: main.c main.h
