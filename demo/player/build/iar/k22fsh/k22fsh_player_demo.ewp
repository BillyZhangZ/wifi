# IAR project k22fsh_player_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22DN512xxx5 Freescale MK22DN512xxx5
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pe177,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../../usb/host/source; ../../../../../player/source; ../../../../../audio/include; ../../../../../audio/include/source; ../../../../../usb/host/source/include; ../../../../../usb/common/include; ../../../../../usb/host/source/include; ../../../../../usb/host/source/classes/audio; ../../../../../usb/host/source/classes/aoap; ../../../../../usb/host/source/host/ehci; ../../../../../usb/host/source/classes/bluetooth; ../../../../../usb/host/source/classes/cdc; ../../../../../usb/host/source/classes/hid; ../../../../../usb/host/source/classes/hub; ../../../../../usb/host/source/classes/msd; ../../../../../usb/host/source/classes/msd/mfs; ../../../../../usb/host/source/classes/phdc; ../../../../../usb/host/source/classes/printer; ../../../../../usb/host/source/rtos/mqx; ../../../../../mqx/source/io/adc/kadc; ../../../../../externallibs/bluetooth/include; ../../../../../shell/source/include; ../../../../../bluetooth/Lib/aac; ../../../../../bluetooth/Lib; ../../../../../audio/include; ../../../../../msi/source/; ../../../../../mqx/source/io/adc; ../../../../../mqx/source/io/cm; ../../../../../config/k22fsh; ../../../../../mqx/source/io/dma; ../../../../../mqx/source/io/flashx/freescale; ../../../../../mqx/source/io/flashx; ../../../../../mqx/source/io/gpio/kgpio; ../../../../../mqx/source/io/gpio; ../../../../../mqx/source/io/hwtimer; ../../../../../mqx/source/io/i2c; ../../../../../mqx/source/io/i2c/polled; ../../../../../mqx/source/io/i2c/int; ../../../../../mqx/source/bsp/k22fsh; ../../../../../config/common; ../../../../../mqx/source/include; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/debug; ../../../../../mqx/source/io/io_mem; ../../../../../mqx/source/io/io_null; ../../../../../mqx/source/io/pipe; ../../../../../mqx/source/io/lpm; ../../../../../mqx/source/io/lwadc; ../../../../../mqx/source/io/lwgpio; ../../../../../mqx/source/io/pcb; ../../../../../mqx/source/io/pcb/mqxa; ../../../../../mqx/source/io/pccard; ../../../../../mqx/source/io/pcflash; ../../../../../mqx/source/io/rnga; ../../../../../mqx/source/io/rtc; ../../../../../mqx/source/io/sai; ../../../../../mqx/source/io/sai/int; ../../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../../mqx/source/io/sdcard; ../../../../../mqx/source/io/serial; ../../../../../mqx/source/io/spi; ../../../../../mqx/source/io/tfs; ../../../../../mqx/source/io/timer; ../../../../../mqx/source/io/usb; ../../../../../mqx/source/psp/cortex_m/cpu; ../../../../../mqx/source/psp/cortex_m; ../../../../../mqx/source/psp/cortex_m/core/M4; ../../../../../mqx/source/tad; ../../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../mfs/source/include; ../../../../../mux/source
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../../../../../usb/host/source; ../../../../../player/source; ../../../../../audio/include; ../../../../../audio/include/source; ../../../../../usb/host/source/include; ../../../../../usb/common/include; ../../../../../usb/host/source/include; ../../../../../usb/host/source/classes/audio; ../../../../../usb/host/source/classes/aoap; ../../../../../usb/host/source/host/ehci; ../../../../../usb/host/source/classes/bluetooth; ../../../../../usb/host/source/classes/cdc; ../../../../../usb/host/source/classes/hid; ../../../../../usb/host/source/classes/hub; ../../../../../usb/host/source/classes/msd; ../../../../../usb/host/source/classes/msd/mfs; ../../../../../usb/host/source/classes/phdc; ../../../../../usb/host/source/classes/printer; ../../../../../usb/host/source/rtos/mqx; ../../../../../mqx/source/io/adc/kadc; ../../../../../bluetooth/Lib; ../../../../../shell/source/include; ../../../../../bluetooth/Lib/aac; ../../../../../bluetooth/Lib; ../../../../../audio/include; ../../../../../msi/source/; ../../../../../mqx/source/io/adc; ../../../../../mqx/source/io/cm; ../../../../../config/k22fsh; ../../../../../mqx/source/io/dma; ../../../../../mqx/source/io/flashx/freescale; ../../../../../mqx/source/io/flashx; ../../../../../mqx/source/io/gpio/kgpio; ../../../../../mqx/source/io/gpio; ../../../../../mqx/source/io/hwtimer; ../../../../../mqx/source/io/i2c; ../../../../../mqx/source/io/i2c/polled; ../../../../../mqx/source/io/i2c/int; ../../../../../mqx/source/bsp/k22fsh; ../../../../../config/common; ../../../../../mqx/source/include; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/debug; ../../../../../mqx/source/io/io_mem; ../../../../../mqx/source/io/io_null; ../../../../../mqx/source/io/pipe; ../../../../../mqx/source/io/lpm; ../../../../../mqx/source/io/lwadc; ../../../../../mqx/source/io/lwgpio; ../../../../../mqx/source/io/pcb; ../../../../../mqx/source/io/pcb/mqxa; ../../../../../mqx/source/io/pccard; ../../../../../mqx/source/io/pcflash; ../../../../../mqx/source/io/rnga; ../../../../../mqx/source/io/rtc; ../../../../../mqx/source/io/sai; ../../../../../mqx/source/io/sai/int; ../../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../../mqx/source/io/sdcard; ../../../../../mqx/source/io/serial; ../../../../../mqx/source/io/spi; ../../../../../mqx/source/io/tfs; ../../../../../mqx/source/io/timer; ../../../../../mqx/source/io/usb; ../../../../../mqx/source/psp/cortex_m/cpu; ../../../../../mqx/source/psp/cortex_m; ../../../../../mqx/source/psp/cortex_m/core/M4; ../../../../../mqx/source/tad; ../../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../mfs/source/include
  OBJCOPY.OOCOutputFile: k22fsh_player_demo.bin
  ILINK.IlinkOutputFile: k22fsh_player_demo.out
  ILINK.IlinkIcfFile: ../../../../../lib/k22fsh.iar/debug/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/k22fsh.iar/debug/bsp/bsp.a; ../../../../../lib/k22fsh.iar/debug/mfs/mfs.a; ../../../../../lib/k22fsh.iar/debug/msi/msi.a; ../../../../../lib/k22fsh.iar/debug/player/player.a; ../../../../../lib/k22fsh.iar/debug/mux/mux.a; ../../../../../lib/k22fsh.iar/debug/psp/psp.a; ../../../../../lib/k22fsh.iar/debug/usb/usb_k22fsh.a; ../../../../../lib/k22fsh.iar/debug/audio/audio.a; ../../../../../lib/k22fsh.iar/debug/audio/codec_metadata.a; ../../../../../lib/k22fsh.iar/debug/audio/mp3dec_lib.a; ../../../../../lib/k22fsh.iar/debug/audio/flacdec_lib.a; ../../../../../lib/k22fsh.iar/debug/audio/wavdec_lib.a; ../../../../../lib/k22fsh.iar/debug/audio/apedec_lib.a; ../../../../../externallibs/bluetooth/iar/bluetooth.a; ../../../../../lib/k22fsh.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../../../lib/k22fsh.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/k22fsh.iar/release/bsp/bsp.a; ../../../../../lib/k22fsh.iar/release/mfs/mfs.a; ../../../../../lib/k22fsh.iar/release/msi/msi.a; ../../../../../lib/k22fsh.iar/release/player/player.a; ../../../../../lib/k22fsh.iar/release/mux/mux.a; ../../../../../lib/k22fsh.iar/release/psp/psp.a; ../../../../../lib/k22fsh.iar/release/usb/usb_k22fsh.a; ../../../../../lib/k22fsh.iar/release/audio/audio.a; ../../../../../lib/k22fsh.iar/release/audio/codec_metadata.a; ../../../../../lib/k22fsh.iar/release/audio/mp3dec_lib.a; ../../../../../lib/k22fsh.iar/release/audio/flacdec_lib.a; ../../../../../lib/k22fsh.iar/release/audio/wavdec_lib.a; ../../../../../lib/k22fsh.iar/release/audio/apedec_lib.a; ../../../../../externallibs/bluetooth/iar/bluetooth.a; ../../../../../lib/k22fsh.iar/release/shell/shell.a
  group source
    ../../../source/: adk20.c adk20.h aoa_task.c aoa_task.h main.c main.h MFS_USB.h sd_task.c sd_task.h shell_init.c umass_task.c umass_task.h usb_bluetooth_task.c usb_bluetooth_task.h usb_classes.c usb_classes.h USB_File.c USB_File.h usb_mfi_task.c usb_mfi_task.h
