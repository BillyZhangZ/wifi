# IAR project bluetooth_uart_k22fsh.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pe177,Pe550,Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\lib\k22fsh.iar\debug; ..\..\..\..\..\lib\k22fsh.iar\debug\psp; ..\..\..\..\..\lib\k22fsh.iar\debug\bsp; ..\..\..\..\..\lib\k22fsh.iar\debug\bsp\Generated_Code; ..\..\..\..\..\lib\k22fsh.iar\debug\shell; ..\..\..\..\..\lib\k22fsh.iar\debug\msi; ..\..\..\..\..\lib\k22fsh.iar\debug\bluetooth; ..\..\..\..\..\mux\source; ..\..\..\..\..\externallibs\bluetooth\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bluetooth_uart_k22fsh.bin
  ILINK.IlinkOutputFile: bluetooth_uart_k22fsh.out
  ILINK.IlinkIcfFile: ../../../../../lib/k22fsh.iar/debug/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\lib\k22fsh.iar\debug\bsp\bsp.a; ..\..\..\..\..\lib\k22fsh.iar\debug\psp\psp.a; ..\..\..\..\..\lib\k22fsh.iar\debug\msi\msi.a; ..\..\..\..\..\lib\k22fsh.iar\debug\shell\shell.a; ..\..\..\..\..\lib\k22fsh.iar\debug\mux\mux.a; ..\..\..\..\..\externallibs\bluetooth\iar\bluetooth.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\..\lib\k22fsh.iar\release; ..\..\..\..\..\lib\k22fsh.iar\release\psp; ..\..\..\..\..\lib\k22fsh.iar\release\bsp; ..\..\..\..\..\lib\k22fsh.iar\release\bsp\Generated_Code; ..\..\..\..\..\lib\k22fsh.iar\release\shell; ..\..\..\..\..\lib\k22fsh.iar\release\msi; ..\..\..\..\..\lib\k22fsh.iar\release\bluetooth; ..\..\..\..\..\mux\source; ..\..\..\..\..\externallibs\bluetooth\include
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../../../lib/k22fsh.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\lib\k22fsh.iar\release\bsp\bsp.a; ..\..\..\..\..\lib\k22fsh.iar\release\psp\psp.a; ..\..\..\..\..\lib\k22fsh.iar\release\msi\msi.a; ..\..\..\..\..\lib\k22fsh.iar\release\shell\shell.a; ..\..\..\..\..\lib\k22fsh.iar\release\mux\mux.a; ..\..\..\..\..\externallibs\bluetooth\iar\bluetooth.a
  group Source
    ../../../Sources/: main.c main.h shell_init.c UART_Task.c
