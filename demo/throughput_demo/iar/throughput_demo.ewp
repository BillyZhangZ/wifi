# IAR project throughput_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN1M0xxx12 Freescale MK22FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1; __ATHEROS_FS__=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186,Pe111,Pe009,Pe550,Pe177
  ICCARM.CCIncludePath2: ../../../mqx/source/io/enet; ../../../mqx/source/io/enet/atheros_wifi; ../../../mqx/source/io/enet/atheros_wifi/include; ../../../mqx/source/io/enet/atheros_wifi/common_src/include; ../../../mqx/source/io/enet/atheros_wifi/custom_src/include; ../../../demo/throughput_demo/custom; ../../../rtcs/source/include; ../../../shell/source/include; ../../../lib/sp140k22f.iar/debug/psp; ../../../lib/sp140k22f.iar/debug/bsp/Sources; ../../../lib/sp140k22f.iar/debug/bsp/Generated_Code; ../../../lib/sp140k22f.iar/debug/bsp; ../../../lib/sp140k22f.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../../../lib/sp140k22f.iar/debug/psp; ../../../lib/sp140k22f.iar/debug/bsp/Sources; ../../../lib/sp140k22f.iar/debug/bsp/Generated_Code; ../../../lib/sp140k22f.iar/debug/bsp; ../../../lib/sp140k22f.iar/debug
  OBJCOPY.OOCOutputFile: throughput_demo.bin
  ILINK.IlinkOutputFile: throughput_demo.out
  ILINK.IlinkIcfFile: ../../../lib/sp140k22f.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../lib/sp140k22f.iar/debug/bsp/bsp.a; ../../../lib/sp140k22f.iar/debug/mfs/mfs.a; ../../../lib/sp140k22f.iar/debug/psp/psp.a; ../../../lib/sp140k22f.iar/debug/rtcs/rtcs.a; ../../../lib/sp140k22f.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __ATHEROS_FS__=1
  ICCARM.CCIncludePath2: ../../../mqx/source/io/enet; ../../../mqx/source/io/enet/atheros_wifi; ../../../mqx/source/io/enet/atheros_wifi/include; ../../../mqx/source/io/enet/atheros_wifi/common_src/include; ../../../mqx/source/io/enet/atheros_wifi/custom_src/include; ../../../demo/throughput_demo/custom; ../../../rtcs/source/include; ../../../shell/source/include; ../../../lib/sp140k22f.iar/release/psp; ../../../lib/sp140k22f.iar/release/bsp/Sources; ../../../lib/sp140k22f.iar/release/bsp/Generated_Code; ../../../lib/sp140k22f.iar/release/bsp; ../../../lib/sp140k22f.iar/release
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../lib/sp140k22f.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../lib/sp140k22f.iar/release/bsp/bsp.a; ../../../lib/sp140k22f.iar/release/mfs/mfs.a; ../../../lib/sp140k22f.iar/release/psp/psp.a; ../../../lib/sp140k22f.iar/release/rtcs/rtcs.a; ../../../lib/sp140k22f.iar/release/shell/shell.a
configuration Int Ram Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: K60Xxxx Freescale K60Xxxx
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: ..\..\..\lib\twrk60n512.iar\bsp; ..\..\..\lib\twrk60n512.iar\psp; ..\..\..\lib\twrk60n512.iar; ..\..\..\lib\twrk60n512.iar\rtcs; ..\..\..\lib\twrk60n512.iar\mfs; ..\..\..\lib\twrk60n512.iar\usb\host; ..\..\..\lib\twrk60n512.iar\shell; ..
  ICCARM.CCOptLevel: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: config_twrk60n512.out
  ILINK.IlinkIcfFile: ..\..\..\lib\sp140k22f.iar\debug\bsp\intflash.icf
configuration Int Ram Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NDEBUG
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe186
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ..\..\..\lib\sp140k22f.iar\release\bsp\intflash.icf
  group Source/common
    ../common/: wmiconfig.c
  group Source/custom
    ../custom/: Command_Lists.c https.c https.h main.h RTCS.c rtcs_throughput.c Shell_Task.c task_manager.c Tasks.c throughput.c throughput.h usb_classes.h utils.c wmiconfig_custom.c
    ../../config_tool/sensor/: sensor.c tmp106.c tmp106.h
  group Source/driver_plugin
    ../driver_plugin/: atheros_wifi_mediactl_ext.c
