# IAR project throughput_twrk22_qca4002.ewp, settings and files
configuration Int Flash SramData Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SRAM_DATA_TARGET; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/Generated_Code; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/Sources; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/psp; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/shell; $MQX_ROOTDIR$/mqx/source/io/enet; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi/include; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi/common_src/include; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi/custom_src/include; $MQX_ROOTDIR$/demo/throughput_demo/custom; $MQX_ROOTDIR$/rtcs/source/include; $MQX_ROOTDIR$/shell/source/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/Generated_Code; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/Sources; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/psp; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/shell
  OBJCOPY.OOCOutputFile: throughput_twrk22_qca4002.srec
  ILINK.IlinkOutputFile: throughput.out
  ILINK.IlinkIcfFile: $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/bsp.a; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/psp/psp.a; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/shell/shell.a; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/rtcs/rtcs.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash SramData Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCIncludePath2: ../../../../../lib/twrk22_qca4002.iar/release/bsp/Generated_Code; ../../../../../lib/twrk22_qca4002.iar/release/bsp/Sources; ../../../../../lib/twrk22_qca4002.iar/release; ../../../../../lib/twrk22_qca4002.iar/release/bsp; ../../../../../lib/twrk22_qca4002.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: pe_demo.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrk22_qca4002.iar/release/bsp/intflash_sramdata.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrk22_qca4002.iar/release/bsp/bsp.a; ../../../../../lib/twrk22_qca4002.iar/release/psp/psp.a
configuration Int Flash DDRData Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET; _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../lib/twrk22_qca4002.iar/debug/bsp/Generated_Code; ../../../../../lib/twrk22_qca4002.iar/debug/bsp/Sources; ../../../../../lib/twrk22_qca4002.iar/debug; ../../../../../lib/twrk22_qca4002.iar/debug/bsp; ../../../../../lib/twrk22_qca4002.iar/debug/psp
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: pe_demo.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrk22_qca4002.iar/debug/bsp/intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrk22_qca4002.iar/debug/bsp/bsp.a; ../../../../../lib/twrk22_qca4002.iar/debug/psp/psp.a
configuration Int Flash DDRData Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: pe_demo.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrk22_qca4002.iar/release/bsp/intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: as above
  group Source/common
    ../../../common/: wmiconfig.c
  group Source/custom
    ../../../custom/: Command_Lists.c https.c RTCS.c rtcs_throughput.c Shell_Task.c task_manager.c Tasks.c throughput.c utils.c wmiconfig_custom.c
  group Source/driver_plugin
    ../../../driver_plugin/: atheros_wifi_mediactl_ext.c
  group Source/sensor
    ../../../sensor/: sensor.c tmp106.c
