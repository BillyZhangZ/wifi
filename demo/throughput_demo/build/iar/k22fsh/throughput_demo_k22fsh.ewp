# IAR project throughput_demo_k22fsh.ewp, settings and files
configuration Int Flash SramData Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: SRAM_DATA_TARGET; _DEBUG=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174,Pa050
  ICCARM.CCIncludePath2: ../../../../../lib/k22fsh.iar/debug/bsp/Generated_Code; ../../../../../lib/k22fsh.iar/debug/bsp/Sources; ../../../../../lib/k22fsh.iar/debug; ../../../../../lib/k22fsh.iar/debug/bsp; ../../../../../lib/k22fsh.iar/debug/psp; ../../../../../lib/k22fsh.iar/debug/shell; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/enet/atheros_wifi; ../../../../../mqx/source/io/enet/atheros_wifi/include; ../../../../../mqx/source/io/enet/atheros_wifi/common_src/include; ../../../../../mqx/source/io/enet/atheros_wifi/custom_src/include; ../../../../../demo/throughput_demo/custom; ../../../../../rtcs/source/include; ../../../../../shell/source/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: ../../../../../lib/k22fsh.iar/debug/bsp/Generated_Code; ../../../../../lib/k22fsh.iar/debug/bsp/Sources; ../../../../../lib/k22fsh.iar/debug; ../../../../../lib/k22fsh.iar/debug/bsp; ../../../../../lib/k22fsh.iar/debug/psp; ../../../../../lib/k22fsh.iar/debug/shell
  OBJCOPY.OOCOutputFile: throughput_demo_k22fsh.srec
  ILINK.IlinkOutputFile: throughput.out
  ILINK.IlinkIcfFile: ../../../../../lib/k22fsh.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: ../../../../../lib/k22fsh.iar/debug/bsp/bsp.a; ../../../../../lib/k22fsh.iar/debug/psp/psp.a; ../../../../../lib/k22fsh.iar/debug/shell/shell.a; ../../../../../lib/k22fsh.iar/debug/rtcs/rtcs.a; ../../../../../lib/k22fsh.iar/debug/mux/mux.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash SramData Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCIncludePath2: ../../../../../lib/k22fsh.iar/release/bsp/Generated_Code; ../../../../../lib/k22fsh.iar/release/bsp/Sources; ../../../../../lib/k22fsh.iar/release; ../../../../../lib/k22fsh.iar/release/bsp; ../../../../../lib/k22fsh.iar/release/psp; ../../../../../lib/k22fsh.iar/release/shell; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/enet/atheros_wifi; ../../../../../mqx/source/io/enet/atheros_wifi/include; ../../../../../mqx/source/io/enet/atheros_wifi/common_src/include; ../../../../../mqx/source/io/enet/atheros_wifi/custom_src/include; ../../../../../demo/throughput_demo/custom; ../../../../../rtcs/source/include; ../../../../../shell/source/include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: ../../../../../lib/k22fsh.iar/release/bsp/Generated_Code; ../../../../../lib/k22fsh.iar/release/bsp/Sources; ../../../../../lib/k22fsh.iar/release; ../../../../../lib/k22fsh.iar/release/bsp; ../../../../../lib/k22fsh.iar/release/psp; ../../../../../lib/k22fsh.iar/release/shell
  ILINK.IlinkIcfFile: ../../../../../lib/k22fsh.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/k22fsh.iar/release/bsp/bsp.a; ../../../../../lib/k22fsh.iar/release/psp/psp.a; ../../../../../lib/k22fsh.iar/release/shell/shell.a; ../../../../../lib/k22fsh.iar/release/rtcs/rtcs.a; ../../../../../lib/k22fsh.iar/release/mux/mux.a
  group Source/common
    ../../../common/: wmiconfig.c
  group Source/custom
    ../../../custom/: Command_Lists.c https.c RTCS.c rtcs_throughput.c Shell_Task.c task_manager.c Tasks.c throughput.c utils.c wmiconfig_custom.c
  group Source/driver_plugin
    ../../../driver_plugin/: atheros_wifi_mediactl_ext.c
  group Source/sensor
    ../../../sensor/: sensor.c tmp106.c
