# IAR project p2p_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN1M0xxx12 Freescale MK22FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: _DEBUG=1
  ICCARM.CCIncludePath2: ../../../mqx/source/include; ../../../mqx/source/io/enet; ../../../mqx/source/io/enet/atheros_wifi; ../../../mqx/source/io/enet/atheros_wifi/include; ../../../mqx/source/io/enet/atheros_wifi/common_src/include; ../../../mqx/source/io/enet/atheros_wifi/custom_src/include; ../../../demo/p2p_demo/custom; ../../../rtcs/source/include; ../../../shell/source/include; ../../../lib/sp140k22f.iar/debug/psp; ../../../lib/sp140k22f.iar/debug/bsp/Sources; ../../../lib/sp140k22f.iar/debug/bsp/Generated_Code; ../../../lib/sp140k22f.iar/debug/bsp; ../../../lib/sp140k22f.iar/debug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../../../lib/sp140k22f.iar/debug/psp; ../../../lib/sp140k22f.iar/debug/bsp/Sources; ../../../lib/sp140k22f.iar/debug/bsp/Generated_Code; ../../../lib/sp140k22f.iar/debug/bsp; ../../../lib/sp140k22f.iar/debug
  OBJCOPY.OOCOutputFile: p2p_demo.bin
  ILINK.IlinkOutputFile: p2p_demo.out
  ILINK.IlinkIcfFile: ../../../lib/sp140k22f.iar/debug/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../lib/sp140k22f.iar/debug/bsp/bsp.a; ../../../lib/sp140k22f.iar/debug/mfs/mfs.a; ../../../lib/sp140k22f.iar/debug/psp/psp.a; ../../../lib/sp140k22f.iar/debug/rtcs/rtcs.a; ../../../lib/sp140k22f.iar/debug/shell/shell.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ../../../mqx/source/include; ../../../mqx/source/io/enet; ../../../mqx/source/io/enet/atheros_wifi; ../../../mqx/source/io/enet/atheros_wifi/include; ../../../mqx/source/io/enet/atheros_wifi/common_src/include; ../../../mqx/source/io/enet/atheros_wifi/custom_src/include; ../../../demo/p2p_demo/custom; ../../../rtcs/source/include; ../../../shell/source/include; ../../../lib/sp140k22f.iar/release/psp; ../../../lib/sp140k22f.iar/release/bsp/Sources; ../../../lib/sp140k22f.iar/release/bsp/Generated_Code; ../../../lib/sp140k22f.iar/release/bsp; ../../../lib/sp140k22f.iar/release
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ../../../lib/sp140k22f.iar/release/bsp/intflash.icf
  ILINK.IlinkAdditionalLibs: ../../../lib/sp140k22f.iar/release/bsp/bsp.a; ../../../lib/sp140k22f.iar/release/mfs/mfs.a; ../../../lib/sp140k22f.iar/release/psp/psp.a; ../../../lib/sp140k22f.iar/release/rtcs/rtcs.a; ../../../lib/sp140k22f.iar/release/shell/shell.a
  group Source/common
    ../common/: wmiconfig.c
  group Source/custom
    ../custom/: Command_Lists.c main.h RTCS.c rtcs_throughput.c Shell_Task.c task_manager.c Tasks.c throughput.c throughput.h usb_classes.h utils.c wmiconfig_custom.c
    ../../config_tool/sensor/: sensor.c tmp106.c tmp106.h
  group Source/driver_plugin
    ../driver_plugin/: atheros_wifi_mediactl_ext.c
