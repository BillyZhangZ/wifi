# IAR project ACServerSample_k22fsh.ewp, settings and files
configuration Int Flash SramData Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN256xxx12 Freescale MK22FN256xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SRAM_DATA_TARGET; _DEBUG=1; xAJ_CONFIGURE_WIFI_UPON_START; CONFIG_SERVICE; NOTIFICATION_SERVICE_PRODUCER; ONBOARDING_SERVICE; CONTROLPANEL_SERVICE; AJ_DEBUG_RESTRICT=AJ_DEBUG_INFO; xER_DEBUG_ALL; ER_DEBUG_AJSVCALL=1; ER_DEBUG_AJSVCAPP=1; xER_DEBUG_AJSVC=1; xER_DEBUG_AJCFG=1; xER_DEBUG_AJOBS=1; xER_DEBUG_AJNS=1; xER_DEBUG_AJCPS=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: $MQX_ROOTDIR$/lib/k22fsh.iar/debug/bsp/Generated_Code; $MQX_ROOTDIR$/lib/k22fsh.iar/debug/bsp/Sources; $MQX_ROOTDIR$/lib/k22fsh.iar/debug; $MQX_ROOTDIR$/lib/k22fsh.iar/debug/bsp; $MQX_ROOTDIR$/lib/k22fsh.iar/debug/psp; $MQX_ROOTDIR$/rtcs/source/include; $MQX_ROOTDIR$/mqx/source/io/enet; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi/include; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi/common_src/include; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi/custom_src/include; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi/custom_src/stack_custom; $MQX_ROOTDIR$/demo/aj/alljoyn/aj_sp140-141mqx/inc; $MQX_ROOTDIR$/demo/aj/allseen/core/ajtcl/inc; $MQX_ROOTDIR$/demo/aj/allseen/core/about_tcl/tcl/inc; $MQX_ROOTDIR$/demo/aj/allseen/services/services_common/tcl/inc; $MQX_ROOTDIR$/demo/aj/allseen/services/config/tcl/inc; $MQX_ROOTDIR$/demo/aj/allseen/services/onboarding/tcl/inc; $MQX_ROOTDIR$/demo/aj/allseen/services/notification/tcl/inc; $MQX_ROOTDIR$/demo/aj/allseen/services/controlpanel/tcl/inc; $MQX_ROOTDIR$/demo/aj/allseen/services/sample_apps/tcl/AppsCommon/inc; $MQX_ROOTDIR$/demo/aj/allseen/services/sample_apps/tcl/SmartPlug
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: $MQX_ROOTDIR$/lib/k22fsh.iar/debug/bsp/Generated_Code; $MQX_ROOTDIR$/lib/k22fsh.iar/debug/bsp/Sources; $MQX_ROOTDIR$/lib/k22fsh.iar/debug; $MQX_ROOTDIR$/lib/k22fsh.iar/debug/bsp; $MQX_ROOTDIR$/lib/k22fsh.iar/debug/psp
  OBJCOPY.OOCOutputFile: SmartPlug_k22fsh.srec
  ILINK.IlinkOutputFile: SmartPlug.out
  ILINK.IlinkIcfFile: $MQX_ROOTDIR$/lib/k22fsh.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: $MQX_ROOTDIR$/lib/k22fsh.iar/debug/bsp/bsp.a; $MQX_ROOTDIR$/lib/k22fsh.iar/debug/psp/psp.a; $MQX_ROOTDIR$/lib/k22fsh.iar/debug/rtcs/rtcs.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash SramData Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCIncludePath2: ../../../../../lib/k22fsh.iar/release/bsp/Generated_Code; ../../../../../lib/k22fsh.iar/release/bsp/Sources; ../../../../../lib/k22fsh.iar/release; ../../../../../lib/k22fsh.iar/release/bsp; ../../../../../lib/k22fsh.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: pe_demo.out
  ILINK.IlinkIcfFile: ../../../../../lib/k22fsh.iar/release/bsp/intflash_sramdata.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/k22fsh.iar/release/bsp/bsp.a; ../../../../../lib/k22fsh.iar/release/psp/psp.a
configuration Int Flash DDRData Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  ICCARM.CCDefines: DDR_DATA_TARGET; _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../lib/k22fsh.iar/debug/bsp/Generated_Code; ../../../../../lib/k22fsh.iar/debug/bsp/Sources; ../../../../../lib/k22fsh.iar/debug; ../../../../../lib/k22fsh.iar/debug/bsp; ../../../../../lib/k22fsh.iar/debug/psp
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: pe_demo.out
  ILINK.IlinkIcfFile: ../../../../../lib/k22fsh.iar/debug/bsp/intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/k22fsh.iar/debug/bsp/bsp.a; ../../../../../lib/k22fsh.iar/debug/psp/psp.a
configuration Int Flash DDRData Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  ICCARM.CCDefines: DDR_DATA_TARGET
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: pe_demo.out
  ILINK.IlinkIcfFile: ../../../../../lib/k22fsh.iar/release/bsp/intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: as above
  group Source/aj/alljoyn
    ../../../../../../../core/ajtcl/src/: aj_init.c
    ../../../../../../../../alljoyn/aj_sp140-141mqx/src/: aj_net.c aj_target_crypto.c aj_target_nvram.c aj_target_util.c aj_tasks.c aj_wifi_ctrl.c AllJoyn.c atheros_wifi_mediactl_ext.c net_utils.c
  group Source/aj/allseen/core/about_tcl
    ../../../../../../../core/about_tcl/tcl/src/: AboutIcon.c AboutSample.c AboutService.c
  group Source/aj/allseen/core/ajtcl
    ../../../../../../../core/ajtcl/src/: aj_auth.c aj_bufio.c aj_bus.c aj_connect.c aj_creds.c aj_crypto.c aj_debug.c aj_disco.c aj_guid.c aj_helper.c aj_introspect.c aj_link_timeout.c aj_msg.c aj_peer.c aj_sasl.c aj_std.c aj_util.c
    ../../../../../../../core/ajtcl/crypto/: aj_sw_crypto.c
  group Source/aj/allseen/services/common
    ../../../../AppsCommon/src/: PropertyStore.c Services_Handlers.c
    ../../../../../../services_common/tcl/src/: Services_Common.c
  group Source/aj/allseen/services/config
    ../../../../AppsCommon/src/: ConfigSample.c
    ../../../../../../config/tcl/src/: ConfigService.c
  group Source/aj/allseen/services/control_panel
    ../../../: ControlPanelGenerated.c ControlPanelProvided.c ControlPanelSample.c
  group Source/aj/allseen/services/control_panel/cps_controllee
    ../../../../../../controlpanel/tcl/src/CPSControllee/: ControlPanelInterfaces.c ControlPanelService.c
  group Source/aj/allseen/services/control_panel/cps_controllee/common
    ../../../../../../controlpanel/tcl/src/CPSControllee/Common/: BaseWidget.c ConstraintList.c ConstraintRange.c ControlMarshalUtil.c DateTimeUtil.c HttpControl.c
  group Source/aj/allseen/services/control_panel/cps_controllee/widgets
    ../../../../../../controlpanel/tcl/src/CPSControllee/Widgets/: ActionWidget.c ContainerWidget.c DialogWidget.c LabelWidget.c PropertyWidget.c
  group Source/aj/allseen/services/notification_producer
    ../../../: ACNotificationProducerSample.c
    ../../../../../../notification/tcl/src/NotificationCommon/: NotificationCommon.c
    ../../../../../../notification/tcl/src/NotificationProducer/: NotificationProducer.c
  group Source/aj/allseen/services/onboarding
    ../../../../../../onboarding/tcl/src/: OnboardingManager.c OnboardingService.c
    ../../../../AppsCommon/src/: OnboardingSample.c
  group Source/smartplug_sample
    ../../../: PeripheralHandle.c SmartPlug.c
