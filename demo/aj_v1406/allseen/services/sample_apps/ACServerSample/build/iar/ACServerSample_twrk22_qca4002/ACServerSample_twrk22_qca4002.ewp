# IAR project ACServerSample_twrk22_qca4002.ewp, settings and files
configuration Int Flash SramData Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SRAM_DATA_TARGET; _DEBUG=1; xAJ_CONFIGURE_WIFI_UPON_START; CONFIG_SERVICE; NOTIFICATION_SERVICE_PRODUCER; ONBOARDING_SERVICE; CONTROLPANEL_SERVICE; AJ_DEBUG_RESTRICT=AJ_DEBUG_INFO; xER_DEBUG_ALL; ER_DEBUG_AJSVCALL=1; ER_DEBUG_AJSVCAPP=1; xER_DEBUG_AJSVC=1; xER_DEBUG_AJCFG=1; xER_DEBUG_AJOBS=1; xER_DEBUG_AJNS=1; xER_DEBUG_AJCPS=1
  ICCARM.CCDiagSuppress: Pa082,Pe186,Pe177,Pe550,Pe174
  ICCARM.CCIncludePath2: $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/Generated_Code; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/Sources; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/psp; $MQX_ROOTDIR$/rtcs/source/include; $MQX_ROOTDIR$/mqx/source/io/enet; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi/include; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi/common_src/include; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi/custom_src/include; $MQX_ROOTDIR$/mqx/source/io/enet/atheros_wifi/custom_src/stack_custom; $MQX_ROOTDIR$/demo/aj_v1406/alljoyn/aj_sp140-141mqx/inc; $MQX_ROOTDIR$/demo/aj_v1406/allseen/core/ajtcl/bsp; $MQX_ROOTDIR$/demo/aj_v1406/allseen/core/ajtcl/inc; $MQX_ROOTDIR$/demo/aj_v1406/allseen/core/about_tcl/tcl/inc; $MQX_ROOTDIR$/demo/aj_v1406/allseen/core/ajtcl/inc; $MQX_ROOTDIR$/demo/aj_v1406/allseen/core/ajtcl/external/sha2; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/services_common/inc; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/services_common/inc/alljoyn/services_common; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/config/inc; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/config/inc/alljoyn/vconfig; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/onboarding/inc/; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/onboarding/inc/alljoyn/onboarding; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/notification/inc; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/notification/inc/alljoyn/notification; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/controlpanel/inc/alljoyn/controlpanel; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/controlpanel/inc/alljoyn/controlpanel/Common; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/controlpanel/inc/alljoyn/controlpanel/Widgets; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/controlpanel/inc/; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/sample_apps/AppsCommon/inc; $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/sample_apps/ACServerSample
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _DEBUG=1
  AARM.AUserIncludes: $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/Generated_Code; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/Sources; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/psp
  OBJCOPY.OOCOutputFile: ACServerSample_twrk22_qca4002.srec
  ILINK.IlinkOutputFile: ACServerSample.out
  ILINK.IlinkIcfFile: $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkAdditionalLibs: $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/bsp/bsp.a; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/psp/psp.a; $MQX_ROOTDIR$/lib/twrk22_qca4002.iar/debug/rtcs/rtcs.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Int Flash SramData Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SRAM_DATA_TARGET
  ICCARM.CCIncludePath2: ../../../../../lib/twrk22_qca4002.iar/release/bsp/Generated_Code; ../../../../../lib/twrk22_qca4002.iar/release/bsp/Sources; ../../../../../lib/twrk22_qca4002.iar/release; ../../../../../lib/twrk22_qca4002.iar/release/bsp; ../../../../../lib/twrk22_qca4002.iar/release/psp
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: pe_demo.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrk22_qca4002.iar/release/bsp/intflash_sramdata.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrk22_qca4002.iar/release/bsp/bsp.a; ../../../../../lib/twrk22_qca4002.iar/release/psp/psp.a
configuration Int Flash DDRData Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET; _DEBUG=1
  ICCARM.CCIncludePath2: ../../../../../lib/twrk22_qca4002.iar/debug/bsp/Generated_Code; ../../../../../lib/twrk22_qca4002.iar/debug/bsp/Sources; ../../../../../lib/twrk22_qca4002.iar/debug; ../../../../../lib/twrk22_qca4002.iar/debug/bsp; ../../../../../lib/twrk22_qca4002.iar/debug/psp
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: pe_demo.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrk22_qca4002.iar/debug/bsp/intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: ../../../../../lib/twrk22_qca4002.iar/debug/bsp/bsp.a; ../../../../../lib/twrk22_qca4002.iar/debug/psp/psp.a
configuration Int Flash DDRData Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DDR_DATA_TARGET
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: pe_demo.out
  ILINK.IlinkIcfFile: ../../../../../lib/twrk22_qca4002.iar/release/bsp/intflash_ddrdata.icf
  ILINK.IlinkAdditionalLibs: as above
  group Source/ACServerSample
    ../../../: ACServerSample.c
  group Source/aj/alljoyn
    $MQX_ROOTDIR$/demo/aj_v1406/alljoyn/aj_sp140-141mqx/src/: aj_net.c aj_target_crypto.c aj_target_nvram.c aj_target_util.c aj_tasks.c aj_wifi_ctrl.c AllJoyn.c atheros_wifi_mediactl_ext.c crc.c net_utils.c
  group Source/aj/allseen/core/ajtcl
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/core/ajtcl/src/: aj_about.c aj_bufio.c aj_bus.c aj_cert.c aj_connect.c aj_crc16.c aj_creds.c aj_crypto.c aj_debug.c aj_disco.c aj_guid.c aj_helper.c aj_init.c aj_introspect.c aj_keyauthentication.c aj_keyexchange.c aj_link_timeout.c aj_msg.c aj_peer.c aj_std.c aj_util.c
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/core/ajtcl/crypto/ecc/: aj_crypto_ecc.c aj_crypto_sha2.c
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/core/ajtcl/crypto/: aj_sw_crypto.c
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/core/ajtcl/external/sha2/: sha2.c
  group Source/aj/allseen/services/common
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/sample_apps/AppsCommon/src/: AppHandlers.c PropertyStore.c
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/services_common/src/: ServicesCommon.c ServicesHandlers.c
  group Source/aj/allseen/services/config
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/sample_apps/AppsCommon/src/: ConfigSample.c
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/config/src/: ConfigService.c
  group Source/aj/allseen/services/control_panel
    ../../../: ControlPanelGenerated.c ControlPanelProvided.c ControlPanelSample.c
  group Source/aj/allseen/services/control_panel/cps_controllee
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/controlpanel/src/CPSControllee/: ControlPanelInterfaces.c ControlPanelService.c
  group Source/aj/allseen/services/control_panel/cps_controllee/common
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/controlpanel/src/CPSControllee/Common/: BaseWidget.c ConstraintList.c ConstraintRange.c ControlMarshalUtil.c DateTimeUtil.c HttpControl.c
  group Source/aj/allseen/services/control_panel/cps_controllee/widgets
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/controlpanel/src/CPSControllee/Widgets/: ActionWidget.c ContainerWidget.c DialogWidget.c LabelWidget.c PropertyWidget.c
  group Source/aj/allseen/services/notification_producer
    ../../../: ACNotificationProducerSample.c
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/notification/src/NotificationCommon/: NotificationCommon.c
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/notification/src/NotificationProducer/: NotificationProducer.c
  group Source/aj/allseen/services/onboarding
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/onboarding/src/: OnboardingManager.c OnboardingService.c
    $MQX_ROOTDIR$/demo/aj_v1406/allseen/services/sample_apps/AppsCommon/src/: OnboardingSample.c
