<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ACServerSample_twrk22_qca4002.ewp</path>
  </project>
  <batchBuild/>
</workspace>


