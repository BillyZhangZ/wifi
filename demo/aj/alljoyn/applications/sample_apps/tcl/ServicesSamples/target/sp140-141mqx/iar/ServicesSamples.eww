<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ServicesSamples.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\..\aj_sp140-141mqx\mqx\build\iar\bsp_sp140_kf\bsp_sp140_kf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\..\..\..\aj_sp140-141mqx\mqx\build\iar\psp_sp140_kf\psp_sp140_kf.ewp</path>
  </project>
  <batchBuild/>
</workspace>


