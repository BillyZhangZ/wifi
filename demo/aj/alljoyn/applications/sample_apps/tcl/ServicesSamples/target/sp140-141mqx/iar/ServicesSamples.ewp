# IAR project ServicesSamples.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN1M0xxx12 Freescale MK22FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AJ_NUM_REPLY_CONTEXTS=2; AJ_MAX_OBJECT_LISTS=8; xAJ_CONFIGURE_WIFI_UPON_START; xWIFI_SSID; xWIFI_PASSPHRASE; xSOFTAP_SSID; xSOFTAP_PASSPHRASE; xSCAN_INFO; CONFIG_SERVICE; xNOTIFICATION_SERVICE_CONSUMER; NOTIFICATION_SERVICE_PRODUCER; ONBOARDING_SERVICE; CONTROLPANEL_SERVICE; EVENTS_AND_ACTIONS; _DEBUG=1; AJ_DEBUG_RESTRICT=AJ_DEBUG_INFO; ER_DEBUG_ALL=1; ER_DEBUG_AJSVCALL=1; ER_DEBUG_AJSVCAPP=1; ER_DEBUG_AJSVC=1; ER_DEBUG_AJCFG=1; ER_DEBUG_AJOBS=1; ER_DEBUG_AJNS=1; ER_DEBUG_AJCPS=1
  ICCARM.CCDiagSuppress: Pe188,Pe167,Pa050
  ICCARM.CCIncludePath2: ../../../../../../../aj_sp140-141mqx/inc; ../../../../../../../aj_sp140-141mqx/rtcs/source/include; ../../../../../../../aj_sp140-141mqx/mqx/source/io/enet; ../../../../../../../aj_sp140-141mqx/mqx/source/io/enet/atheros_wifi; ../../../../../../../aj_sp140-141mqx/mqx/source/io/enet/atheros_wifi/include; ../../../../../../../aj_sp140-141mqx/mqx/source/io/enet/atheros_wifi/common_src/include; ../../../../../../../aj_sp140-141mqx/mqx/source/io/enet/atheros_wifi/custom_src/include; ../../../../../../../aj_sp140-141mqx/mqx/source/io/enet/atheros_wifi/common_src/stack_common; ../../../../../../../aj_sp140-141mqx/mqx/source/io/enet/atheros_wifi/custom_src/stack_custom; ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/psp; ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/rtcs; ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/bsp/Sources; ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/bsp/Generated_Code; ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/bsp; ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug; ../../../../../../../../allseen/core/ajtcl/inc; ../../../../../../../../allseen/core/ajtcl/malloc; ../../../../../../../../allseen/core/ajtcl/external/sha2; ..\..\..\..\..\..\..\..\allseen\services\base_tcl\services_common\inc; ..\..\..\..\..\..\..\..\allseen\services\base_tcl\config\inc; ..\..\..\..\..\..\..\..\allseen\services\base_tcl\onboarding\inc; ..\..\..\..\..\..\..\..\allseen\services\base_tcl\notification\inc; ..\..\..\..\..\..\..\..\allseen\services\base_tcl\controlpanel\inc; ..\..\..\..\..\..\..\..\allseen\services\base_tcl\sample_apps\AppsCommon\inc; ..\..\..\..\..\..\..\..\allseen\services\base_tcl\sample_apps\ServerSample
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/psp; ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/bsp/Sources; ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/bsp/Generated_Code; ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/bsp; ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug
  OBJCOPY.OOCOutputFile: ServicesSample.bin
  ILINK.IlinkOutputFile: ServicesSample.out
  ILINK.IlinkIcfFile: ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; AJ_NUM_REPLY_CONTEXTS=2; AJ_MAX_OBJECT_LISTS=8; xAJ_CONFIGURE_WIFI_UPON_START; CONFIG_SERVICE; xNOTIFICATION_SERVICE_CONSUMER; NOTIFICATION_SERVICE_PRODUCER; ONBOARDING_SERVICE; CONTROLPANEL_SERVICE; EVENTS_AND_ACTIONS
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkIcfFile: ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/release/bsp/intflash.icf
  group AJ_Core/AJ_TCL
    ../../../../../../../../allseen/core/ajtcl/src/: aj_about.c aj_bufio.c aj_bus.c aj_cert.c aj_connect.c aj_creds.c aj_crypto.c aj_debug.c aj_disco.c aj_guid.c aj_helper.c aj_init.c aj_introspect.c aj_keyauthentication.c aj_keyexchange.c aj_link_timeout.c aj_msg.c aj_peer.c aj_std.c aj_util.c
    ../../../../../../../../allseen/core/ajtcl/crypto/ecc/: aj_crypto_ecc.c aj_crypto_sha2.c
    ../../../../../../../../allseen/core/ajtcl/malloc/: aj_malloc.c
    ../../../../../../../../allseen/core/ajtcl/crypto/: aj_sw_crypto.c
    ../../../../../../../../allseen/core/ajtcl/external/sha2/: sha2.c
  group AJ_Core/AJ_Test
    ../../../../../../../../allseen/core/ajtcl/test/: nvramtest.c siglite.c svclite.c
  group AJ_Services/Common
    ../../../../../../../../allseen/services/base_tcl/sample_apps/AppsCommon/src/: PropertyStore.c
    ../../../../../../../../allseen/services/base_tcl/services_common/src/: ServicesCommon.c ServicesHandlers.c
  group AJ_Services/Config
    ../../../../../../../../allseen/services/base_tcl/config/src/: ConfigService.c
  group AJ_Services/ControlPanel/CPSControllee
    ../../../../../../../../allseen/services/base_tcl/controlpanel/src/CPSControllee/: ControlPanelInterfaces.c ControlPanelService.c
  group AJ_Services/ControlPanel/CPSControllee/Common
    ../../../../../../../../allseen/services/base_tcl/controlpanel/src/CPSControllee/Common/: BaseWidget.c ConstraintList.c ConstraintRange.c ControlMarshalUtil.c DateTimeUtil.c HttpControl.c
  group AJ_Services/ControlPanel/CPSControllee/Widgets
    ../../../../../../../../allseen/services/base_tcl/controlpanel/src/CPSControllee/Widgets/: ActionWidget.c ContainerWidget.c DialogWidget.c LabelWidget.c PropertyWidget.c
  group AJ_Services/Notification/Common
    ../../../../../../../../allseen/services/base_tcl/notification/src/NotificationCommon/: NotificationCommon.c
  group AJ_Services/Notification/Consumer
    ../../../../../../../../allseen/services/base_tcl/notification/src/NotificationConsumer/: NotificationConsumer.c
  group AJ_Services/Notification/Producer
    ../../../../../../../../allseen/services/base_tcl/notification/src/NotificationProducer/: NotificationProducer.c
  group AJ_Services/Onboarding
    ../../../../../../../../allseen/services/base_tcl/onboarding/src/: OnboardingManager.c OnboardingService.c
  group AJ_Services/SampleApps
    ../../../../../../../../allseen/services/base_tcl/sample_apps/: ConfigSample.c NotificationConsumerSample.c NotificationProducerSample.c OnboardingSample.c
  group AJ_Services/SampleApps/ACServerSample
    ../../../../../../../../allseen/services/base_tcl/sample_apps/ACServerSample/: ACNotificationProducerSample.c ACServerSample.c ControlPanelGenerated.c ControlPanelProvided.c ControlPanelSample.c EventsAndActionsSample.c
  group AJ_Services/SampleApps/AppsCommon
    ../../../../../../../../allseen/services/base_tcl/sample_apps/AppsCommon/src/: AppHandlers.c ConfigSample.c OnboardingSample.c
  group AJ_Services/SampleApps/ControlleeSample
    ../../../../../../../../allseen/services/base_tcl/sample_apps/: ControlleeSample.c ControlPanelGenerated.c ControlPanelProvided.c
  group AJ_Services/SampleApps/ServerSample
    ../../../../../../../../allseen/services/base_tcl/sample_apps/ServerSample/: ControlPanelGenerated.c ControlPanelProvided.c ControlPanelSample.c ServerSample.c SimpleNotificationConsumerSample.c SimpleNotificationProducerSample.c
  group AJ_Target
    ../../../../../../../aj_sp140-141mqx/src/: aj_net.c aj_target_crypto.c aj_target_nvram.c aj_target_util.c aj_tasks.c aj_wifi_ctrl.c AllJoyn.c atheros_wifi_mediactl_ext.c net_utils.c
  group MQX Libraries/Debug
    ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/bsp/: bsp.a
    ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/debug/psp/: psp.a
  group MQX Libraries/Release
    ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/release/bsp/: bsp.a
    ../../../../../../../aj_sp140-141mqx/lib/sp140k22f.iar/release/psp/: psp.a
