# IAR project AllJoyn.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN1M0xxx12 Freescale MK22FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: AJ_CONFIGURE_WIFI_UPON_START; _DEBUG=1; AJ_DEBUG_RESTRICT=AJ_DEBUG_ALL; AJ_NVRAM_SIZE=12000; WIFI_SCAN=; WIFI_SSID="AllJoyn"; WIFI_PASSPHRASE="ajajajaj"; xSOFTAP_SSID="AJTCL"; xSOFTAP_PASSPHRASE="alljoyn123"
  ICCARM.CCDiagSuppress: Pe167,Pa050
  ICCARM.CCIncludePath2: ../inc; ../rtcs/source/include; ../mqx/source/io/enet; ../mqx/source/io/enet/atheros_wifi; ../mqx/source/io/enet/atheros_wifi/include; ../mqx/source/io/enet/atheros_wifi/common_src/include; ../mqx/source/io/enet/atheros_wifi/custom_src/include; ../mqx/source/io/enet/atheros_wifi/common_src/stack_common; ../mqx/source/io/enet/atheros_wifi/custom_src/stack_custom; ../lib/sp140k22f.iar/debug/psp; ../lib/sp140k22f.iar/debug/bsp/Sources; ../lib/sp140k22f.iar/debug/bsp/Generated_Code; ../lib/sp140k22f.iar/debug/bsp; ../lib/sp140k22f.iar/debug; ../../../allseen/core/ajtcl/inc; ../../../allseen/core/ajtcl/malloc; ../../../allseen/core/ajtcl/external/sha2
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ../lib/sp140k22f.iar/debug/bsp/Sources; ../lib/sp140k22f.iar/debug/bsp/Generated_Code; ../lib/sp140k22f.iar/debug/bsp; ../lib/sp140k22f.iar/debug
  OBJCOPY.OOCOutputFile: AllJoyn.bin
  ILINK.IlinkOutputFile: AllJoyn.out
  ILINK.IlinkIcfFile: ../lib/sp140k22f.iar/debug/bsp/intflash.icf
  ILINK.IlinkExtraOptions: --redirect __iar_dlmalloc=malloc; --redirect __iar_dlcalloc=calloc; --redirect __iar_dlfree=free
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; AJ_CONFIGURE_WIFI_UPON_START; WIFI_SSID="AllJoyn"; WIFI_PASSPHRASE="ajajajaj"
  ICCARM.CCIncludePath2: ../inc; ../rtcs/source/include; ../mqx/source/io/enet; ../mqx/source/io/enet/atheros_wifi; ../mqx/source/io/enet/atheros_wifi/include; ../mqx/source/io/enet/atheros_wifi/common_src/include; ../mqx/source/io/enet/atheros_wifi/custom_src/include; ../mqx/source/io/enet/atheros_wifi/common_src/stack_common; ../mqx/source/io/enet/atheros_wifi/custom_src/stack_custom; ../lib/sp140k22f.iar/release/psp; ../lib/sp140k22f.iar/release/bsp/Sources; ../lib/sp140k22f.iar/release/bsp/Generated_Code; ../lib/sp140k22f.iar/release/bsp; ../lib/sp140k22f.iar/release; ../../../allseen/core/ajtcl/inc; ../../../allseen/core/ajtcl/malloc; ../../../allseen/core/ajtcl/external/sha2
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  AARM.AUserIncludes: ../lib/sp140k22f.iar/release/bsp/Sources; ../lib/sp140k22f.iar/release/bsp/Generated_Code; ../lib/sp140k22f.iar/release/bsp; ../lib/sp140k22f.iar/release
  ILINK.IlinkIcfFile: ../lib/sp140k22f.iar/release/bsp/intflash.icf
  group AJ_Test
    ../../../allseen/core/ajtcl/test/: nvramtest.c siglite.c svclite.c
  group AJTCL
    ../../../allseen/core/ajtcl/src/: aj_about.c aj_bufio.c aj_bus.c aj_cert.c aj_connect.c aj_creds.c aj_crypto.c aj_debug.c aj_disco.c aj_guid.c aj_helper.c aj_init.c aj_introspect.c aj_keyauthentication.c aj_keyexchange.c aj_link_timeout.c aj_msg.c aj_peer.c aj_std.c aj_util.c
    ../../../allseen/core/ajtcl/crypto/ecc/: aj_crypto_ecc.c aj_crypto_sha2.c
    ../../../allseen/core/ajtcl/malloc/: aj_malloc.c
    ../../../allseen/core/ajtcl/crypto/: aj_sw_crypto.c
    ../../../allseen/core/ajtcl/external/sha2/: sha2.c
  group MQX Libraries
    ../lib/sp140k22f.iar/debug/bsp/: bsp.a
    ../lib/sp140k22f.iar/release/bsp/: bsp.a
    ../lib/sp140k22f.iar/debug/psp/: psp.a
    ../lib/sp140k22f.iar/release/psp/: psp.a
  group src
    ../src/: aj_net.c aj_target_crypto.c aj_target_nvram.c aj_target_util.c aj_tasks.c aj_wifi_ctrl.c AllJoyn.c atheros_wifi_mediactl_ext.c net_utils.c
