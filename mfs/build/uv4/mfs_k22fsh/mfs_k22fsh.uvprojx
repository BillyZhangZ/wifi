# Keil uVision project mfs_k22fsh.uvprojx, settings and files
target mfs_k22fsh Debug (ARM-ADS)
  device: MK22FN512xxx12 Freescale
  pack: Keil.Kinetis_K20_DFP.1.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mfs (library)
  AfterMake: ../../../../mfs/build/bat/mfs_k22fsh.bat ../../../.. ../../../../lib/k22fsh.uv4/debug/mfs uv4 & ".copy.bat" "Debug/mfs.lib" "../../../../lib/k22fsh.uv4/debug/mfs/mfs.lib"
  c flags: Optim=1 OneElfS=1
  c define: _DEBUG=1
  c misc: --library_interface=armcc 
 --library_type=standardlib 
--c99
 --diag_suppress=1296,186
  c include: ../../../source/include;../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/adc;../../../../mqx/source/io/cm;../../../../config/k22fsh;../../../../mqx/source/io/dma;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/flashx;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/gpio;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/i2c;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/i2c/int;../../../../mqx/source/bsp/k22fsh;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/io/enet;../../../../mqx/source/io/debug;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/io_null;../../../../mqx/source/io/pipe;../../../../mqx/source/io/lpm;../../../../mqx/source/io/lwadc;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/pcb;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/pccard;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/rnga;../../../../mqx/source/io/rtc;../../../../mqx/source/io/sai;../../../../mqx/source/io/sai/int;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/serial;../../../../mqx/source/io/spi;../../../../mqx/source/io/tfs;../../../../mqx/source/io/timer;../../../../mqx/source/io/usb;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/core/M4;../../../../mqx/source/tad
  asm define: _DEBUG=1
  asm misc: --cpreproc 
 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  scatter file: ..\..\..\lib\k22fsh.uv4\mqx\intflash.scf
  group MFS Include
    ../../../source/include/: mfs_cnfg.h mfs_prv.h mfs_rev.h mfs.h part_mgr.h
  group MFS Source
    ../../../source/generic/: dir_read.c mfs_attribute.c mfs_cluster.c mfs_create.c mfs_data_sector.c mfs_delete.c mfs_dir_entry.c mfs_directory.c mfs_fat.c mfs_format.c mfs_handle.c mfs_init.c mfs_lfn.c mfs_misc.c mfs_open.c mfs_parse.c mfs_read.c mfs_rename.c mfs_rw.c mfs_search.c mfs_time.c mfs_valdev.c mfs_write.c part_mgr.c
target mfs_k22fsh Release (ARM-ADS)
  device: MK22DN512xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: mfs (library)
  AfterMake: ../../../../mfs/build/bat/mfs_twrk22f120m.bat ../../../.. ../../../../lib/twrk22f120m.uv4/release/mfs uv4 & ".copy.bat" "Release/mfs.lib" "../../../../lib/twrk22f120m.uv4/release/mfs/mfs.lib"
  c flags: Optim=4 OneElfS=1
  c misc: as above
  c include: ../../../source/include;../../../../mqx/source/io/adc/kadc;../../../../mqx/source/io/adc;../../../../mqx/source/io/cm;../../../../config/twrk22f120m;../../../../mqx/source/io/dma;../../../../mqx/source/io/flashx/freescale;../../../../mqx/source/io/flashx;../../../../mqx/source/io/gpio/kgpio;../../../../mqx/source/io/gpio;../../../../mqx/source/io/hwtimer;../../../../mqx/source/io/i2c;../../../../mqx/source/io/i2c/polled;../../../../mqx/source/io/i2c/int;../../../../mqx/source/bsp/twrk22f120m;../../../../config/common;../../../../mqx/source/include;../../../../mqx/source/io/enet;../../../../mqx/source/io/debug;../../../../mqx/source/io/io_mem;../../../../mqx/source/io/io_null;../../../../mqx/source/io/pipe;../../../../mqx/source/io/lpm;../../../../mqx/source/io/lwadc;../../../../mqx/source/io/lwgpio;../../../../mqx/source/io/pcb;../../../../mqx/source/io/pcb/mqxa;../../../../mqx/source/io/pccard;../../../../mqx/source/io/pcflash;../../../../mqx/source/io/rnga;../../../../mqx/source/io/rtc;../../../../mqx/source/io/sai;../../../../mqx/source/io/sai/int;../../../../mqx/source/io/sdcard/sdcard_spi;../../../../mqx/source/io/sdcard;../../../../mqx/source/io/serial;../../../../mqx/source/io/spi;../../../../mqx/source/io/tfs;../../../../mqx/source/io/timer;../../../../mqx/source/io/usb;../../../../mqx/source/psp/cortex_m/compiler/rv_uv4;../../../../mqx/source/psp/cortex_m/cpu;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/core/M4;../../../../mqx/source/tad
  asm misc: --cpreproc 
 --diag_suppress=1609,1581
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk22f120m.uv4\mqx\intflash.scf
