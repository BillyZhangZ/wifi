# IAR project usb_k22fsh.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK22FN512xxx12 Freescale MK22FN512xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa050,Pe177,Pe550
  ICCARM.CCIncludePath2: ../../../../common/include; ../../../source/include; ../../../source/classes/audio; ../../../source/host/ehci; ../../../source/classes/bluetooth; ../../../source/classes/cdc; ../../../source/classes/hid; ../../../source/classes/hub; ../../../source/classes/msd; ../../../source/classes/msd/mfs; ../../../source/classes/phdc; ../../../source/classes/printer; ../../../source/rtos/mqx; ../../../../../mqx/source/io/adc/kadc; ../../../../../mqx/source/io/adc; ../../../../../mqx/source/io/cm; ../../../../../config/k22fsh; ../../../../../mqx/source/io/dma; ../../../../../mqx/source/io/flashx/freescale; ../../../../../mqx/source/io/flashx; ../../../../../mqx/source/io/gpio/kgpio; ../../../../../mqx/source/io/gpio; ../../../../../mqx/source/io/hwtimer; ../../../../../mqx/source/io/i2c; ../../../../../mqx/source/io/i2c/polled; ../../../../../mqx/source/io/i2c/int; ../../../../../mqx/source/bsp/k22fsh; ../../../../../config/common; ../../../../../mqx/source/include; ../../../../../mqx/source/io/enet; ../../../../../mqx/source/io/debug; ../../../../../mqx/source/io/io_mem; ../../../../../mqx/source/io/io_null; ../../../../../mqx/source/io/pipe; ../../../../../mqx/source/io/lpm; ../../../../../mqx/source/io/lwadc; ../../../../../mqx/source/io/lwgpio; ../../../../../mqx/source/io/pcb; ../../../../../mqx/source/io/pcb/mqxa; ../../../../../mqx/source/io/pccard; ../../../../../mqx/source/io/pcflash; ../../../../../mqx/source/io/rnga; ../../../../../mqx/source/io/rtc; ../../../../../mqx/source/io/sai; ../../../../../mqx/source/io/sai/int; ../../../../../mqx/source/io/sdcard/sdcard_spi; ../../../../../mqx/source/io/sdcard; ../../../../../mqx/source/io/serial; ../../../../../mqx/source/io/spi; ../../../../../mqx/source/io/tfs; ../../../../../mqx/source/io/timer; ../../../../../mqx/source/io/usb; ../../../../../mqx/source/psp/cortex_m/cpu; ../../../../../mqx/source/psp/cortex_m; ../../../../../mqx/source/psp/cortex_m/core/M4; ../../../../../mqx/source/tad; ../../../../../mqx/source/psp/cortex_m/compiler/iar; ../../../../../mfs/source/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  postbuild: ../../../../../usb/host/build/bat/usb_k22fsh.bat ../../../../.. ../../../../../lib/k22fsh.iar/debug/usb iar
  ILINK.IlinkOutputFile: usb_twrk22f120m.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCOptLevel: 0
  postbuild: ../../../../../usb/host/build/bat/usb_k22fsh.bat ../../../../.. ../../../../../lib/k22fsh.iar/release/usb iar
  ILINK.IlinkOutputFile: usb_k22fsh.out
  group source
    ../../../source/host/: host_ch9.c host_close.c host_cnl.c host_common.c host_dev_list.c host_main.c host_rcv.c host_shut.c host_snd.c
    ../../../source/host/khci/: khci.c
    ../../../source/rtos/mqx/: mqx_dll.c usb_mqx.c
    ../../../source/classes/aoap/: usb_host_aoa.c
    ../../../source/classes/audio/: usb_host_audio.c usb_host_audio_intf.c
    ../../../source/classes/bluetooth/: usb_host_bluetooth.c
    ../../../source/classes/cdc/: usb_host_cdc.c usb_host_cdc_intf.c
    ../../../source/classes/hid/: usb_host_hid.c
    ../../../source/classes/hub/: usb_host_hub.c usb_host_hub_sm.c
    ../../../source/classes/msd/: usb_host_msd_bo.c usb_host_msd_queue.c usb_host_msd_ufi.c
    ../../../source/classes/phdc/: usb_host_phdc.c
    ../../../source/classes/printer/: usb_host_printer.c
    ../../../source/classes/msd/mfs/: usbmfs.c
